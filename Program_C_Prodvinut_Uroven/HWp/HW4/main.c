/*
//------------------------------------------------------
//       Игра змейка продолжение 4
//------------------------------------------------------ 
1. Добавить возможность управления змейкой клавишами
WSAD (вне зависимости от регистра).
Зависимости от регистра в соответствии с таблицей.
    W, w            Вверх
    S,s             Вниз
    A,a             Влево
    D,d             Вправо

Для решения предлагается сделать массив кодов управления struct
control_buttons default_controls[CONTROLS]. 
CONTROLS – определяем количество элементов массива.
В необходимых функциях в цикле необходимо сравнивать с каждым
типом управления в цикле
for (int i = 0; i < CONTROLS; i++)

2. Написать функцию, которая будет проверять корректность выбранного
направления. Змейка не может наступать на хвост, поэтому необходимо запретить
● перемещение справа-налево (при движении RIGHT нажатие стрелки влево),
● перемещение сверху-вниз (при движении UP нажатие стрелки вниз),
● перемещение слева-направо (при движении LEFT нажатие стрелки вправо),
● перемещение снизу-вверх (при движении DOWN нажатие стрелки вверх).
Функция должна иметь вид:
int checkDirection(snake_t* snake, int32_t key).

*/

#include <stdio.h>      // стандартный ввод-вывод (printf, etc.)
#include <stdlib.h>     // функции работы с памятью (malloc, free)
#include <time.h>       // работа со временем (clock)
#include <ncurses.h>    // библиотека для работы с «графикой» в терминале
#include <inttypes.h>   // типы с фиксированной разрядностью (int32_t)
#include <string.h>     // функции работы со строками (strlen)
#include <unistd.h>     // POSIX-функции (здесь напрямую не нужны, но можно оставить)

//------------------------------------------------------
// Константы и перечисления
//------------------------------------------------------

// Минимальная координата Y, с которой может двигаться змейка.
// Строки 0 и 1 используются под текст/подсказки.
#define MIN_Y 1
#define CONTROLS 3

// Перечисление направлений движения змейки и кода остановки игры.
// STOP_GAME соответствует нажатию клавиши F10 (макрос KEY_F(10) из ncurses).
enum {LEFT=1, UP, RIGHT, DOWN, STOP_GAME=KEY_F(10)};
//LEFT=1 здесь выбрано просто как явное начальное число для перечисления, чтобы дальше
//шли подряд UP = 2, RIGHT = 3, DOWN = 4.

// Разные игровые параметры и «заделы на будущее».
enum {
    MAX_TAIL_SIZE       = 100,  // максимальная длина хвоста (размер массива сегментов)
    START_TAIL_SIZE     = 3,    // начальная длина хвоста (количество видимых сегментов)
    MAX_FOOD_SIZE       = 200,   // максимальное количество еды
    SEED_NUMBER         = 30,     //количество еды на поле
    FOOD_EXPIRE_SECONDS = 10    // время жизни еды
    
};

//------------------------------------------------------
// Структуры
//------------------------------------------------------

// Структура, описывающая коды клавиш управления змейкой.
struct control_buttons {
    int down;   // код клавиши "вниз"
    int up;     // код клавиши "вверх"
    int left;   // код клавиши "влево"
    int right;  // код клавиши "вправо"
};     // объявление переменной (не используется, но не мешает)

// Набор кнопок по умолчанию — стрелки клавиатуры и клавиши W,S,A,D,w,s,a,d.
struct control_buttons default_controls[CONTROLS] = {
    {KEY_DOWN, KEY_UP, KEY_LEFT, KEY_RIGHT}, // 0: стрелки
    {'S', 'W', 'A', 'D'},                    // 1: верхний регистр                
    {'s', 'w', 'a','d'}                      // 2: нижний регистр
    };

// Один сегмент хвоста: хранит только координаты на экране.
typedef struct tail_t {
    int x;      // x-координата сегмента хвоста
    int y;      // y-координата сегмента хвоста
} tail_t;

// Структура, описывающая состояние змейки целиком.
typedef struct snake_t {
    int x;                     // x-координата головы змейки
    int y;                     // y-координата головы змейки
    int direction;             // текущее направление движения (LEFT/RIGHT/UP/DOWN)
    size_t tsize;              // текущая длина хвоста (количество сегментов, которые рисуем)
    tail_t *tail;              // указатель на динамический массив сегментов хвоста
} snake_t;

//--------------------------------------------------------------------
// Еда
//Еда — это массив точек, состоящий из координат x,y, времени, когда
//данная точка была установлена, и поля, сигнализирующего, была ли
//данная точка съедена.
//--------------------------------------------------------------------
typedef struct food {
    int x;                      // x-координата еды
    int y;                      // y-координата еды
    time_t put_time;            //время когда эта еда была длбавлена на поле
    char point;                 //символ которым она представлена
    uint8_t enable;             //флаг, активна эта еда или неактивна
} food_t;                       //создаем массив под еду - глобальный

//------------------------------------------------------
// Инициализация
//------------------------------------------------------

// Инициализация массива хвоста начальными координатами (0,0).
// Это «пустое» состояние — хвост визуально ещё не появился.
void initTail(tail_t t[], size_t size)
{
    tail_t init_t = {0, 0};         // создаём сегмент с координатами (0,0)
    for (size_t i = 0; i < size; i++) // проходим по всем элементам массива
        t[i] = init_t;              // инициализируем каждый сегмент значением init_t
}

// Инициализация головы змейки: начальные координаты и направление.
void initHead(snake_t *head, int x, int y)
{
    head->x = x;                    // устанавливаем начальную x-координату головы
    head->y = y;                    // устанавливаем начальную y-координату головы
    head->direction = RIGHT;        // по умолчанию змейка двигается вправо
}

// Полная инициализация змейки:
// - выделение памяти под хвост,
// - обнуление хвоста,
// - установка головы,
// - назначение управления.
void initSnake(snake_t *head, size_t size, int x, int y)
{
    tail_t* tail = (tail_t*) malloc(MAX_TAIL_SIZE * sizeof(tail_t)); // выделяем память под MAX_TAIL_SIZE сегментов
    initTail(tail, MAX_TAIL_SIZE);                                   // обнуляем весь хвост (все сегменты в (0,0))

    initHead(head, x, y);                                            // устанавливаем начальные координаты и направление головы

    head->tail = tail;                                               // присваиваем указатель на хвост змейке
    head->tsize = size;                                              // задаём текущую длину хвоста (START_TAIL_SIZE)
    //head->controls = default_controls;                               // назначаем стандартные клавиши управления
}

//Сдвигаем границы экрана на 1 позицию внутрь экрана.
void razmer_okna(int *y, int *x)
{
    int rows, cols;
    getmaxyx(stdscr, rows, cols); // rows = высота, cols = ширина окна

    cols -= 1; // последний допустимый индекс по X
    rows -= 1; // последний допустимый индекс по Y

    *x = cols; // записываем результат в переменную вызывающей стороны
    *y = rows;
}

//Инициализация еды
//В самом начале программы происходит установка начальных значений и
//выделение памяти:За это отвечает функция: void initFood(struct food f[], size_t size).
void initFood(food_t f[], size_t size)
{
    food_t init = {0,0,0,0,0};

    int max_x, max_y;
    razmer_okna(&max_y, &max_x);  // получаем «последние индексы» по X и Y

    for(size_t i=0; i<size; i++)
    {
        f[i] = init;
    }
}
//------------------------------------------------------
// Проверка на столкновение с собой
//------------------------------------------------------

// Проверяем, не совпадает ли позиция головы с каким-либо сегментом хвоста.
// Если да — значит, змейка врезалась сама в себя.
int isSelfCollision(const snake_t *s)
{
    for (size_t i = 0; i < s->tsize; ++i)           // проходим по всем сегментам хвоста
    {
        if (s->tail[i].x == s->x &&                // сравниваем x головы и x сегмента
            s->tail[i].y == s->y)                  // и y головы и y сегмента
            return 1;                              // если совпало — сообщаем о столкновении
    }
    return 0;                                      // столкновения нет
}

//------------------------------------------------------
// Движение головы
//------------------------------------------------------

// Смещает голову змейки на одну клетку в текущем направлении.
// При выходе за границы окна — «зацикливает» координату
// (выход с одной стороны — появление с противоположной).
void go(snake_t *head)
{
    
    char ch = '@';          // символ, которым рисуем голову

    int max_x, max_y;
    razmer_okna(&max_y, &max_x);  // получаем «последние индексы» по X и Y

    /*
    getmaxyx(stdscr, max_y, max_x); — это макрос из ncurses, который возвращает РАЗМЕР окна
    max_y — количество строк (высота окна), max_x — количество столбцов (ширина окна).
    Важно: это именно КОЛИЧЕСТВО, а индексы на экране начинаются с 0.
    То есть если, например max_y = 24, то допустимые y на экране 0 .. 23
    max_x = 80, то допустимые x 0 .. 79.

    */

    // Изменяем координаты головы в зависимости от направления движения.
    switch (head->direction)
    {
        case LEFT:                                      // движение влево
            if (head->x <= 0)                           // если выходим за левую границу
                head->x = max_x;                        // переносим голову к правой границе
            else
                head->x--;                              // иначе просто уменьшаем x на 1
            break;
        case RIGHT:                                     // движение вправо
            if (head->x >= max_x)                       // если выходим за правую границу
                head->x = 0;                            // переносим голову к левой границе
            else
                head->x++;                              // иначе увеличиваем x на 1
            break;
        case UP:                                        // движение вверх
            if (head->y <= MIN_Y)                       // если выходим за верхнюю игровую границу
                head->y = max_y;                        // переносим голову вниз экрана
            else
                head->y--;                              // иначе уменьшаем y на 1
            break;
        case DOWN:                                      // движение вниз
            if (head->y >= max_y)                       // если выходим за нижнюю границу
                head->y = MIN_Y;                        // переносим голову к верхней игровой границе
            else
                head->y++;                              // иначе увеличиваем y на 1
            break;
        default:                                        // на случай некорректного направления
            break;
    }

    mvprintw(head->y, head->x, "%c", ch);               // рисуем символ головы '@' в новой позиции
}

//------------------------------------------------------
// Движение хвоста
//------------------------------------------------------
/*
 head_prev_x, head_prev_y — координаты головы ДО движения.
 Первый сегмент хвоста должен занять именно эти координаты,
 чтобы хвост «шёл» сразу за головой без отставания.
*/
void goTail(snake_t *head, int head_prev_x, int head_prev_y)
{
    char ch = '*';                                       // символ хвоста

    mvprintw(head->tail[head->tsize - 1].y,              // y последнего сегмента хвоста
             head->tail[head->tsize - 1].x,              // x последнего сегмента хвоста
             " ");                                       // затираем последний сегмент пробелом

    for (size_t i = head->tsize - 1; i > 0; i--)         // сдвигаем сегменты с конца к началу
    {
        head->tail[i] = head->tail[i - 1];               // каждый сегмент принимает координаты предыдущего
    }

    head->tail[0].x = head_prev_x;                       // первый сегмент хвоста встаёт туда,
    head->tail[0].y = head_prev_y;                       // где была голова до перемещения

    for (size_t i = 0; i < head->tsize; ++i)             // перерисовываем все сегменты хвоста
    {
        if (head->tail[i].x || head->tail[i].y)          // не рисуем сегменты с координатами (0,0)
            mvprintw(head->tail[i].y,                    // y сегмента
                     head->tail[i].x,                    // x сегмента
                     "%c", ch);                          // рисуем символ хвоста '*'
    }
}

//------------------------------------------------------
// Запрещаем разворот змейки на 180°
//------------------------------------------------------
int checkDirection(snake_t* snake, int32_t key)
{
     // Проверяем, не пытается ли змейка развернуться на 180°.
    if ((snake->direction == LEFT  && key == RIGHT) || // было LEFT, хотят RIGHT
        (snake->direction == RIGHT && key == LEFT ) || // было RIGHT, хотят LEFT
        (snake->direction == UP    && key == DOWN ) || // было UP, хотят DOWN
        (snake->direction == DOWN  && key == UP   ))   // было DOWN, хотят UP
    {
        return 1;                                           // игнорируем такой поворот
    }
    return 0;
}

//------------------------------------------------------
// Изменение направления движения змейки
//------------------------------------------------------
// Меняет направление движения змейки в зависимости от нажатой клавиши.
void changeDirection(snake_t* snake, const int32_t key)
{
    int new_dir = snake->direction;  // кандидат на новое направление

    // перебираем все схемы управления
    for (int i = 0; i < CONTROLS; i++)
    {
        if (key == default_controls[i].down)
            new_dir = DOWN;
        else if (key == default_controls[i].up)
            new_dir = UP;
        else if (key == default_controls[i].right)
            new_dir = RIGHT;
        else if (key == default_controls[i].left)
            new_dir = LEFT;
        else
            continue;  // в этой схеме эта клавиша не подошла — проверяем следующую схему

        // если мы сюда дошли — нашли подходящее new_dir
        if (checkDirection(snake, new_dir))   // разворот на 180°?
            return;                           // да — игнорируем

        snake->direction = new_dir;           // нет — применяем
        return;                               // выходим из функции (другие схемы уже не нужны)
    }

    // если ни одна схема не подошла — ничего не делаем
}


/*
Еда — это массив точек, состоящий из координат x,y, времени, когда данная точка
была установлена, и поля, сигнализирующего, была ли данная точка съедена.
Точки расставляются случайным образом в самом начале программы —
        🍎 putFood(food, SEED_NUMBER),
        🍎 putFoodSeed(struct food *fp).
*/

// Обновить/разместить текущее зерно на поле
void putFoodSeed(food_t *fp)
{
    char spoint[2] = {0}; //строка из одного символа

    int max_x, max_y;
    razmer_okna(&max_y, &max_x);  // получаем «последние индексы» по X и Y

    mvprintw(fp->y, fp->x, " "); //удаляем предыидущее значение еды
    fp->x = rand() % (max_x - 1);//получаем случайным образом координаты x
    fp->y = rand() % (max_y - 2) + 1;//здесь тоже для y, не занимаем верхнюю строку
    fp->put_time = time(NULL);//кладем текущее время 
    fp->point = '$';//кладем символ нашей еды
    fp->enable = 1;//говорим что еда активна
    spoint[0] = fp->point;//делаем строку, состоящую из одного нашего символа
    mvprintw(fp->y, fp->x, "%s", spoint);//печатем эту строку по координатам
                                        //прорисовываем нашу еду
}

// Разместить еду на поле
void putFood(food_t f[], size_t number_seeds)//передаём массив еды, количество зерен
{
    for(size_t i=0; i<number_seeds; i++)
    {
        putFoodSeed(f+i);//засеваем наше поле зернами
    }
}
/*
Обновление еды. Если через какое-то время(FOOD_EXPIRE_SECONDS) точка
устаревает, или же она была съедена(food[i].enable==0, то происходит её
повторная отрисовка и обновление времени — refreshFood(food, SEED_NUMBER)
*/

void refreshFood(food_t f[], int nfood)
{
    char spoint[2] = {0};

    int max_x, max_y;
    razmer_okna(&max_y, &max_x);  // получаем «последние индексы» по X и Y
   
    for(int i=0; i<nfood; i++)
    {
        if( f[i].put_time )
        {
            if( !f[i].enable || (time(NULL) - f[i].put_time) > FOOD_EXPIRE_SECONDS )
            {
                putFoodSeed(f+i);
            }   
        }
    }
}

/*
Съесть зерно
Такое событие возникает, когда координаты головы совпадают с координатой
зерна. В этом случае зерно помечается как enable=0.
Проверка того, является ли какое-то из зерен съеденным, происходит при
помощи функции логической функции haveEat в этом случае происходит
увеличение хвоста на 1 элемент.
*/
_Bool haveEat(snake_t *head, food_t f[], int nfood)
{
    for(size_t i=0; i<nfood; i++)
        if( f[i].enable && head->x == f[i].x && head->y == f[i].y)
        {
            f[i].enable = 0;
            return 1;
        }
    return 0;
}
//------------------------------------------------------
// main — точка входа в программу
//------------------------------------------------------
int main()
{
    // выделяем память под структуру змейки
    snake_t* snake = (snake_t*) malloc(sizeof(snake_t));
    //создаём локальный массив еды  
    food_t food[MAX_FOOD_SIZE]; 
    // инициализируем змейку: хвост, координаты головы, управление                          
    initSnake(snake, START_TAIL_SIZE, 10, MIN_Y + 1);     
    initFood(food, MAX_FOOD_SIZE);
    
    // инициализируем ncurses (переход в специальный режим терминала)
    initscr();
    // включаем обработку функциональных клавиш и стрелок                                            
    keypad(stdscr, TRUE);
    // отключаем буферизацию ввода                                 
    raw();
    // не выводим введённые символы на экран                                                
    noecho();
    // скрываем курсор                                            
    curs_set(FALSE);                                      
    
    //Засеиваем еду в первый раз
    putFood(food, SEED_NUMBER);

    // выводим подсказку в верхней строке
    mvprintw(0, 0, "Use arrows for control. Press 'F10' for EXIT"); 
    
    // делаем getch() неблокирующим (возвращает ERR, если клавиша не нажата)
    timeout(0);                                         

    int key_pressed = 0;                                  // переменная для кода последней нажатой клавиши
    int game_over = 0;                                    // флаг: 1 — змейка врезалась в себя, 0 — пока нет

    const int TICK_MS = 150;                              // период одного шага змейки в миллисекундах
    clock_t last_tick = clock();                          // время последнего шага (берём текущее время)

    // рисуем голову змейки в начальной позиции
    mvprintw(snake->y, snake->x, "@");

    // обновляем экран, чтобы всё отобразилось
    refresh();                                            

    // основной игровой цикл: пока нет столкновения и не нажата F10
    while (!game_over && key_pressed != STOP_GAME)        
    {
        // считываем нажатую клавишу (или ERR, если ничего не нажато)
        key_pressed = getch();                            
                                                              
        // пытаемся изменить направление движения змейки
        changeDirection(snake, key_pressed); 
        //Обновляем еду, - перезасеиваем поле новой едой             
        refreshFood(food, SEED_NUMBER);
        // текущее время
        clock_t now = clock(); 
        // вычисляем, сколько миллисекунд прошло
        double elapsed_ms = (double)(now - last_tick) * 1000.0 / CLOCKS_PER_SEC;                              
            

        // если прошло больше TICK_MS, пора двигать змейку
        if (elapsed_ms >= TICK_MS)                        
        {
            last_tick = now;                              // запоминаем время этого шага

            int old_x = snake->x;                         // сохраняем старую x-координату головы
            int old_y = snake->y;                         // сохраняем старую y-координату головы

            // двигаем хвост: первый сегмент встаёт на старое место головы
            goTail(snake, old_x, old_y);

            // двигаем голову в новом направлении
            go(snake);

            // проверяем, не врезалась ли голова в хвост
            if (isSelfCollision(snake))
                // если да — помечаем, что игра окончена из-за столкновения
                game_over = 1;                            

            // обновляем экран после изменений
            refresh();                                    
        }
    }

    // если игра окончилась из-за столкновения с хвостом
    if (game_over)                                        
    {
        int max_x, max_y;
        razmer_okna(&max_y, &max_x);  // получаем «последние индексы» по X и Y

        const char *msg = "THE END!";                     // текст сообщения при столкновении
        mvprintw(max_y / 2,                               
                 (max_x - (int)strlen(msg)) / 2,          // выводим сообщение по центру по горизонтали
                 "%s", msg);                              // выводим строку msg
        refresh();                                        // отображаем надпись

        clock_t start = clock();                          // запоминаем время начала ожидания
        while ((double)(clock() - start) / CLOCKS_PER_SEC < 2) // ждём примерно 2 секунды
        {
            // Пустой цикл ожидания (busy-wait).
        }
    }

    // Если был нажат F10 (обычный выход)
    if (key_pressed == STOP_GAME)                    
    {
        int max_x, max_y;
        razmer_okna(&max_y, &max_x);  // получаем «последние индексы» по X и Y
       
        const char *msg = "STOP GAME!";                   // текст сообщения при штатном выходе
        mvprintw(max_y / 2,
                 (max_x - (int)strlen(msg)) / 2,          // выводим сообщение по центру по горизонтали
                 "%s", msg);                              // выводим строку msg
        refresh();                                        // отображаем надпись

        clock_t start = clock();                          // запоминаем время начала ожидания
        while ((double)(clock() - start) / CLOCKS_PER_SEC < 2) // ждём примерно 2 секунды
        {
            // Пустой цикл ожидания.
        }
    }

    free(snake->tail);                                    // освобождаем память, выделенную под массив хвоста
    free(snake);                                          // освобождаем память под структуру змейки
    endwin();                                             // завершаем работу ncurses, возвращаем терминал в нормальный режим

    return 0;                                             // успешное завершение программы
}