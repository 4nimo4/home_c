/*
//------------------------------------------------------ 
//          КУРСОВОЙ Практическое задание
//------------------------------------------------------
Составьте программу, которая находит площадь, образуемую данными
уравнениями:

1. f1 = 0.6x + 3
2. f2 = (x − 2)^3 – 1
3. f3 = 3 / x

//------------------------------------------------------ 
//          Требования к программе:
//------------------------------------------------------
1.Основная программа должна поддерживать опции командной строки, при
задании которых:
a. Печатаются абсциссы точек пересечения кривых
b. Печатается число итераций, потребовавшихся на приближённое
решение уравнений при поиске точек пересечения

2.Программа должна поддерживать ключ командной строки –help,
выводящий на печать все допустимые ключи командной строки

3.Вычисление с точностью ε1 корня x уравнения f(x) = g(x) на отрезке [a, b]
должно быть реализовано в отдельной Си-функции root(f, g, a, b, eps1).
Если используется метод касательных или комбинированный метод, то у
root должно быть ещё два параметра функционального типа, позволяющие
вызывать производные функций f и g

4.Вычисление с точностью ε2 величины определённого интеграла от
функции f(x) на отрезке [a, b] должно быть реализовано в отдельной Си-
функции integral(f, a, b, eps2)

5.Си-функции root и integral должны быть предварительно протестированы.
Основная программа должна предоставлять возможности тестирования,
активируемые опцией командной строки

6.Сборка программы должна осуществляться при помощи утилиты make.
Соответствующий файл должен явно или неявно описывать зависимости
между всеми целями сборки. Должны быть определены цели all и clean,
первая из которых полностью собирает программу, а вторая — удаляет все
промежуточные файлы (в частности, объектные модули). Сдаваемый архив
должен включать в себя Makefile

7.Программа должна быть снабжена поясняющими комментариями в
объёме, достаточном для её понимания. Все глобальные и статические
переменные должны быть документированы в комментариях.

//------------------------------------------------------ 
//          Нахождение точек пересечений
//------------------------------------------------------
Для нахождения пересечений функций найдём 0 вспомогательных функций

F1 = f3 - f1
F2 = f3 - f2
F3 = f2 - f1 , где:

f1 = 0.6x + 3
f2 = (x − 2)^3 – 1
f3 = 3 / x

был использован графический калькулятор GeoGebra
найдены точки пересечения:
A = Пересечение(f1,f3(0.8541019662497, 3.5124611797498))
B = Пересечение(f2,f3(3.2439288539037, 0.9248044994543))
C = Пересечение(f1,f2(3.8477602451151, 5.308656147069))
//------------------------------------------------------ 
//          Сборка и запуск
//------------------------------------------------------
make clean
make
./prog --help
./prog --roots
./prog --iters
./prog --area
./prog --test-root
./prog --test-int
*/


#include <stdio.h>           //printf, fprintf и др.
#include <stdlib.h>          //malloc/free, exit и др.
#include <math.h>            //Математические функции: fabs, pow, и и др.
#include <string.h>          //Строковые функции: strcmp для сравнения аргументов командной строки

#define EPS_ROOT 1e-6        //(10^-6)Константа: требуемая точность по x при поиске корней (eps1 из задания)
#define EPS_INT  1e-6        //(10^-6)Константа: требуемая точность по значению интеграла (eps2 из задания)
#define MAX_ITER 1000000     //Максимальное число итераций в итерационных методах (root), защита от зацикливания
#define DERIV_EPS 1e-12      //Чтобы избежать деления на почти ноль в формуле Ньютона 
                             //e-12 выбрано как «достаточно маленькое» число для double по сравнению 
                             //с нашими масштабами и точностью 1e-6.
#define TEST_ROOT_A 0.0      //проверочные значения для тестовых функций 
#define TEST_ROOT_B 2.0      //проверочные значения для тестовых функций 
#define TEST_INTEGR_A 0.0    //проверочные значения для тестовых функций 
#define TEST_INTEGR_B 1.0    //проверочные значения для тестовых функций 

// Определяем тип function как "указатель на функцию, принимающую double и возвращающую double"
typedef double (*function)(double);

//------------------------------------------------------ 
//          Исходные функции
//------------------------------------------------------
// Определение функции f1(x) = 0.6x + 3
double f1(double x)         // Объявляем функцию f1, принимающую double x
{    
    return 0.6 * x + 3.0;    
}

// Определение функции f2(x) = (x − 2)^3 – 1
double f2(double x)         // Объявляем функцию f2, принимающую double x
{    
    double t = x - 2.0;      // Вводим вспомогательную переменную t = (x - 2)
    return t * t * t - 1.0;  // Возвращаем t^3 - 1, то есть (x-2)^3 - 1
}

// Определение функции f3(x) = 3 / x
double f3(double x)         // Объявляем функцию f3, принимающую double x
{
    return 3.0 / x;          // Возвращаем значение 3/x
}

//------------------------------------------------------ 
// Вычисляем производные для использования в методе Ньютона
//------------------------------------------------------
// Первая производная f1'(x) = 0.6 (константа, не зависит от x)
double df1(double x)        // Объявляем функцию df1, формально принимающую double x
{
    (void)x;                 // Явно помечаем x как неиспользуемый, чтобы не было предупреждения от компилятора
    return 0.6;              // Возвращаем постоянное значение 0.6
}

// Первая производная f2'(x) для f2(x) = (x-2)^3 - 1 -> f2'(x) = 3(x-2)^2
double df2(double x)        // Объявляем функцию df2, принимающую double x
{    
    double t = x - 2.0;      // t = (x - 2)
    return 3.0 * t * t;      // Возвращаем 3*(x-2)^2
}

// Первая производная f3'(x) для f3(x) = 3/x -> f3'(x) = -3/x^2
double df3(double x)        // Объявляем функцию df3, принимающую double x
{
    return -3.0 / (x * x);   // Возвращаем -3 / (x^2)
}

//------------------------------------------------------ 
// Вспомогательные разности для удобства вычисления методом Ньютона
//------------------------------------------------------
// Возвращает значение разности (f - g)(x) = f(x) - g(x)
double diff_fg(function f, function g, double x)  // Принимает два указателя на функции f, g и аргумент x
{    
    return f(x) - g(x);                            // Вычисляет f(x) и g(x), возвращает их разность
}

// Возвращает значение разности производных (f' - g')(x) = df(x) - dg(x)
double ddiff_fg(function f, function g,            // Указатели на исходные функции (формально не используем)
                function df, function dg,          // Указатели на их производные df, dg
                double x)                          // Аргумент x
{
    (void)f;                                       // Помечаем f как неиспользуемую переменную
    (void)g;                                       // Помечаем g как неиспользуемую переменную
    return df(x) - dg(x);                          // Возвращаем df(x) - dg(x)
}

//------------------------------------------------------ 
// Функция root() (метод Ньютона)
//------------------------------------------------------
// Универсальная функция поиска корня уравнения f(x) = g(x) на отрезке [a, b]
// Используется метод Ньютона с производными df и dg.
// eps — требуемая точность по x (EPS_ROOT),
// iters — указатель на переменную, куда запишется количество сделанных итераций.
double root(function f, function g,         // Указатели на функции f(x) и g(x)
            function df, function dg,       // Указатели на их производные f'(x) и g'(x)
            double a, double b,             // Левая и правая границы отрезка [a, b]
            double eps,                     // Требуемая точность по x (условие остановки)
            int *iters)                     // Указатель на счётчик итераций
{
    double x = 0.5 * (a + b); // Начальное приближение x0 — середина отрезка [a, b]
    int k = 0;                // Счётчик итераций, изначально 0

    while (k < MAX_ITER)     // Основной цикл метода Ньютона, ограничен MAX_ITER, чтобы избежать зацикливания
    {    
        double fx  = diff_fg(f, g, x);      // Вычисляем значение разности F(x) = f(x) - g(x)
        double dfx = ddiff_fg(f, g, df, dg, x); // Вычисляем производную F'(x) = f'(x) - g'(x)

        if (fabs(dfx) < DERIV_EPS)             // Если |F'(x)| слишком мало (почти ноль), -
            //производная, которая меньше 10^-12 , уже настолько мала, что шаг fx/dfx
            //может стать безумно большим относительно наших масштабов.
        {    
            // то шаг Ньютона x - F(x)/F'(x) становится нестабильным,
            // поэтому останавливаемся (выходим из цикла)
            break;
        }

        double x_next = x - fx / dfx;       // Формула метода Ньютона: x_{n+1} = x_n - F(x_n)/F'(x_n)
        k++;                                // Считаем ещё одну итерацию

        if (fabs(x_next - x) < eps)        // Если модуль приращения по x меньше eps — достигнута нужная точность
        {    
            x = x_next;                     // Сохраняем новое значение x
            break;                          // Выходим из цикла
        }

        x = x_next;                         // Иначе просто переходим к следующей итерации с обновлённым x
    }

    if (iters)                             // Если указатель iters не NULL
    {    
        *iters = k;                         // Записываем туда количество итераций k
    }

    return x;                               // Возвращаем найденное приближение корня
}

//------------------------------------------------------ 
//  Функция integral() (Симпсон)
//------------------------------------------------------
// Численное вычисление определённого интеграла ∫[a,b] f(x) dx
// Метод Симпсона с удвоением числа разбиений до достижения точности eps.
double integral(function f, double a, double b, double eps)
{
    int n = 2;           // Начинаем с 2 равных отрезков (минимальное чётное число разбиений)
    double prev = 0.0;   // Предыдущее значение интеграла для критерия сходимости

    while (1)           // Бесконечный цикл, из которого выйдем через return
    {    
        double h = (b - a) / n;   // Шаг сетки: расстояние между соседними точками разбиения
        double sum1 = 0.0;        // Сумма значений функции в "нечётных" узлах (индексы 1,3,5,...)
        double sum2 = 0.0;        // Сумма значений функции в "чётных" узлах (индексы 2,4,6,...)

        for (int i = 1; i < n; i++)  // Проходим по всем внутренним узлам разбиения
        {    
            double x = a + i * h;     // Текущая точка x_i = a + i*h
            if (i % 2 == 0)           // Если i чётное
                sum2 += f(x);         // добавляем f(x) в сумму чётных узлов
            else                      // Если i нечётное
                sum1 += f(x);         // добавляем f(x) в сумму нечётных узлов
        }

        // Формула Симпсона:
        // I ≈ h/3 * [ f(a) + f(b) + 4*sum1 + 2*sum2 ]
        double I = (h / 3.0) * (f(a) + f(b) + 4.0 * sum1 + 2.0 * sum2);

        // Проверяем сходимость, начиная с момента, когда уже есть минимум два разных значения (n > 2)
        if (n > 2 && fabs(I - prev) < eps)  // Если разность текущего и предыдущего значений меньше eps
        {    
            return I;                         // Считаем, что интеграл посчитан с нужной точностью и возвращаем I
        }

        prev = I;     // Сохраняем текущее значение интеграла как "предыдущее" для следующего шага
        n *= 2;       // Удваиваем число разбиений n (делаем сетку более частой)

        if (n > 1e7)  // Если число разбиений стало слишком большим (защита от бесконечного цикла)
        {
            return I;   // Возвращаем текущее значение I (как есть)
        }
    }
}

//---------------------------------------------------- 
//  Вызов меню
//------------------------------------------------------
// Выводит краткую инструкцию по использованию программы и список доступных опций
void print_help(const char *progname)              // progname — имя программы (argv[0])
{    
                // Печатаем, как вызывать программу
    printf("Usage: %s [options] (Печатаем, как вызывать программу)\n", progname);      
    printf("Options:\n");                           // Заголовок списка опций
                // Опция: показать справку
    printf("  --help           : show this help (показать справку)\n");  
                // Опция: вывести корни
    printf("  --roots          : print x-coordinates of intersections f1,f2,f3 (вывести корни)\n");
                // Опция: вывести числа итераций
    printf("  --iters          : print iteration counts used for root finding (вывести числа итераций)\n");
                // Опция: вычислить площадь  
    printf("  --area           : compute and print area between curves (вычислить площадь)\n");
                // Опция: запустить тест root()
    printf("  --test-root      : run tests for root() (запустить тест root())\n");
                // Опция: запустить тест integral()
    printf("  --test-int       : run tests for integral() (запустить тест integral())\n");
}

//---------------------------------------------------- 
//  Тестовые функции
//------------------------------------------------------
// Тестовая функция f(x) = x^2 для проверки root()
double f_test_root(double x) 
    { 
        return x * x; 
    }

// Тестовая функция g(x) = 0 для проверки root()
double g_test_root(double x) 
    { 
        (void)x;   // да, параметр есть, но мы осознанно его не используем
        return 0.0; 
    }

// Производная f'(x) = 2x
double df_test_root(double x) 
    { 
        return 2.0 * x; 
    }

// Производная g'(x) = 0
double dg_test_root(double x) 
    { 
        (void)x; 
        return 0.0; 
    }

// Функция, запускающая тест root()
void test_root(void) 
{
    int iters = 0;                              // Переменная для хранения числа итераций
    double r = root(f_test_root, g_test_root,   // Ищем корень уравнения x^2 = 0
                    df_test_root, dg_test_root, // с производными 2x и 0
                    TEST_ROOT_A, TEST_ROOT_B,                   // на отрезке [0, 2]
                    EPS_ROOT, &iters);          // с точностью EPS_ROOT, записывая кол-во итераций в iters
    printf("test_root: root(x^2=0) on [%.1f,%.1f] ≈ %.10f (iters=%d)\n",TEST_ROOT_A, TEST_ROOT_B, r, iters); // Выводим найденный корень и итерации
}

// Тестовая функция для integral() — берём f1(x)
double f_test_int(double x) 
{ 
    return f1(x); 
}

// Функция, запускающая тест integral()
void test_integral(void) 
{
    // Теоретический результат интеграла ∫_0^1 (0.6x+3) dx = 3.3
    // Численно считаем интеграл f1 от 0 до 1 с точностью EPS_INT
    double I = integral(f_test_int, TEST_INTEGR_A, TEST_INTEGR_B, EPS_INT); 
    // Печатаем результат и точное значение
    printf("test_integral: ∫_%.f^%.f (0.6x+3) dx ≈ %.10f (exact = 3.3)\n",TEST_INTEGR_A, TEST_INTEGR_B, I); 
}    

//---------------------------------------------------- 
//Вспомогательная функция: определяет, какая из двух функций выше на середине отрезка [a, b]
//------------------------------------------------------
// Возвращает +1, если f(mid) > g(mid), иначе -1.
int is_above(function f, function g, double a, double b) 
{
    double mid = 0.5 * (a + b);          // Находим середину отрезка [a, b]
    return (f(mid) > g(mid)) ? 1 : -1;   // Если f(mid) > g(mid), возвращаем 1, иначе -1
}

int main(int argc, char *argv[])
{
    // Если программа запущена без аргументов (argc == 1),
    // просто выводим справку и выходим.
    if (argc == 1) 
    {
        print_help(argv[0]);  // argv[0] — имя запускаемой программы
        return 0;             
    }

    // Логические флаги, обозначающие, какие действия нужны
    int show_roots = 0;     // Нужно ли выводить точки пересечения
    int show_iters = 0;     // Нужно ли выводить числа итераций при поиске корней
    int show_area  = 0;     // Нужно ли вычислять и выводить площадь
    int run_test_root = 0;  // Нужно ли запускать тест root()
    int run_test_int  = 0;  // Нужно ли запускать тест integral()

    // Цикл по всем аргументам командной строки, начиная с argv[1]
    for (int i = 1; i < argc; i++) 
    {
        if (strcmp(argv[i], "--help") == 0) // Если аргумент равен "--help"
        {        
            print_help(argv[0]);                    // Печатаем справку
            return 0;                               
        } 
        else if (strcmp(argv[i], "--roots") == 0) // Если аргумент равен "--roots"
        { 
            show_roots = 1;                         // Включаем флаг show_roots
        } 
        else if (strcmp(argv[i], "--iters") == 0) 
        {
            show_iters = 1;                         
        } else if (strcmp(argv[i], "--area") == 0) 
        {
            show_area = 1;                          
        } else if (strcmp(argv[i], "--test-root") == 0) 
        { 
            run_test_root = 1;                      
        } 
        else if (strcmp(argv[i], "--test-int") == 0) 
        {  
            run_test_int = 1;                       
        } 
        else                                        // Если аргумент неизвестен
        {                                    
            printf("Unknown option (Неизвестный вариант): %s\n", argv[i]); // Печатаем сообщение об ошибочном ключе
            print_help(argv[0]);                    // Показываем справку
            return 1;                               // Возвращаем код ошибки 1
        }
    }

    // Если был указан ключ --test-root, запускаем тест для функции root()
    if (run_test_root) 
    {
        test_root();
    }
    
    if (run_test_int) 
    {
        test_integral();
    }

    //---------------------------------------------------- 
    //Нахождение точек пересечения функций f1, f2, f3
    //------------------------------------------------------
    double x12, x13, x23;             // Переменные для абсцисс пересечений:
                                      // x12 — между f1 и f2,
                                      // x13 — между f1 и f3,
                                      // x23 — между f2 и f3.
    int it12 = 0, it13 = 0, it23 = 0; // Переменные для числа итераций при их нахождении

    // Приближённые значения корней, найденные заранее в GeoGebra:
    double x13_geo = 0.8541019662497;      // Пересечение f1 и f3
    double x23_geo = 3.2439288539037;      // Пересечение f2 и f3
    double x12_geo = 3.8477602451151;      // Пересечение f1 и f2

    // Уточняем положение корня между f3 и f1, используя метод Ньютона,
    // Берем длину отрезка равную 1.0, делим ее пополам ,это есть начальная точка нашего отрезка 
    //стартуем с отрезка [x13_geo-0.5; x13_geo+0.5] отмеряем в разные стороны относительно начальной точки
    x13 = root(f3, f1, df3, df1,
               x13_geo - 0.5, x13_geo + 0.5,
               EPS_ROOT, &it13);

    // Аналогично уточняем пересечение f3 и f2
    x23 = root(f3, f2, df3, df2,
               x23_geo - 0.5, x23_geo + 0.5,
               EPS_ROOT, &it23);

    // Аналогично — пересечение f2 и f1
    x12 = root(f2, f1, df2, df1,
               x12_geo - 0.5, x12_geo + 0.5,
               EPS_ROOT, &it12);

    // Если пользователь указал ключ --roots, выводим найденные корни
    if (show_roots) 
    {
        printf("Intersections(Пересечение) (x):\n");         
        printf("  f1 & f2: x = %.10f\n", x12); // Пересечение f1 и f2
        printf("  f1 & f3: x = %.10f\n", x13); // Пересечение f1 и f3
        printf("  f2 & f3: x = %.10f\n", x23); // Пересечение f2 и f3
    }

    // Если пользователь указал ключ --iters, выводим число итераций root()
    if (show_iters) 
    {
        printf("Iterations used for root finding (Кол-во шагов для пересечения):\n");
        printf("  f1 & f2: %d\n", it12);       // Кол-во шагов для пересечения f1 & f2
        printf("  f1 & f3: %d\n", it13);       // Кол-во шагов для пересечения f1 & f3
        printf("  f2 & f3: %d\n", it23);       // Кол-во шагов для пересечения f2 & f3
    }

    // Если пользователь указал ключ --area, вычисляем площадь фигуры между графиками
    if (show_area) 
    {
        // Из найденных корней знаем порядок по оси X:
        // x13 (f1&f3) < x23 (f2&f3) < x12 (f1&f2)

        // На отрезке [x13; x23] границы образуют функции f2 и f3.
        function top_13_23, bot_13_23;        // Указатели на верхнюю и нижнюю функции на этом отрезке
        if (is_above(f2, f3, x13, x23) > 0)   // Если f2 выше f3 в середине отрезка
        { 
            top_13_23 = f2;                   // f2 — верхняя
            bot_13_23 = f3;                   // f3 — нижняя
        } 
        else                                  // Иначе — наоборот
        {                              
            top_13_23 = f3;                   // f3 — верхняя
            bot_13_23 = f2;                   // f2 — нижняя
        }

        // На отрезке [x23; x12] границы образуют функции f1 и f2.
        function top_23_12, bot_23_12;        // Указатели на верхнюю и нижнюю функции на этом отрезке
        if (is_above(f1, f2, x23, x12) > 0)   // Если f1 выше f2 в середине отрезка
        { 
            top_23_12 = f1;                   // f1 — верхняя
            bot_23_12 = f2;                   // f2 — нижняя
        } 
        else                                  // Иначе f2 выше
        {                              
            top_23_12 = f2;                   // f2 — верхняя
            bot_23_12 = f1;                   // f1 — нижняя
        }

        // Площадь участка между f2 и f3 на [x13; x23]:
        // S1 = ∫(верхняя - нижняя) dx = ∫top_13_23 - ∫bot_13_23
        double area1 = integral(top_13_23, x13, x23, EPS_INT)
                     - integral(bot_13_23, x13, x23, EPS_INT);

        // Площадь участка между f1 и f2 на [x23; x12]:
        // S2 = ∫(верхняя - нижняя) dx = ∫top_23_12 - ∫bot_23_12
        double area2 = integral(top_23_12, x23, x12, EPS_INT)
                     - integral(bot_23_12, x23, x12, EPS_INT);

        // Итоговая площадь фигуры — сумма модулей этих площадей (на всякий случай,
        // чтобы не зависеть от знака вычитания)
        double S = fabs(area1) + fabs(area2);

        // Вывод итоговой площади
        printf("Area between curves(Область между кривыми) = %.10f\n", S);
    }

    return 0;
}