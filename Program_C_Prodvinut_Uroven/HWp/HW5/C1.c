/*
//------------------------------------------------------
//   C1-Префикс и суффикс
//------------------------------------------------------ 
На стандартном потоке ввода задаются две символьные строки, 
разделённые символом перевода строки. Каждая из строк не превышает 
по длине 10000 символов. В строках не встречаются пробельные символы. 
На стандартный поток вывода напечатайте два числа, разделённых пробелом: 
первое число — длина наибольшего префикса первой строки, являющегося 
суффиксом второй; второе число — наоборот, 
длина наибольшего суффикса первой строки, являющегося префиксом второй. 
Сравнение символов проводите с учётом регистра (т.е. символы 'a' и 'A' различны).

*/
#include <stdio.h>
#include <string.h>

#define MAX_LEN 10005

int main(void)
{
    char s1[MAX_LEN];  // первая строка
    char s2[MAX_LEN];  // вторая строка
    // 1) длина наибольшего префикса s1, являющегося суффиксом s2
    int pref1_suf2 = 0;
    // 2) длина наибольшего суффикса s1, являющегося префиксом s2
    int suf1_pref2 = 0;

    // читаем две строки без пробелов (до перевода строки)
    if (scanf("%10000s", s1) != 1)
    {
        printf("%d %d\n", pref1_suf2, suf1_pref2);
        return 0;
    } 
        
    if (scanf("%10000s", s2) != 1) 
     {
        printf("%d %d\n", pref1_suf2, suf1_pref2);
        return 0;
    } 

    int len1 = (int)strlen(s1);
    int len2 = (int)strlen(s2);
    int maxL = (len1 < len2) ? len1 : len2;  // максимальная возможная общая длина

    
    for (int L = maxL; L > 0; L--) 
    {   // пробуем длины от максимальной к меньшим
        int ok = 1;
        int start2 = len2 - L;         // начало суффикса во второй строке
        for (int i = 0; i < L; i++) 
        {
            if (s1[i] != s2[start2 + i]) 
            {
                ok = 0;
                break;
            }
        }
        if (ok) 
        {
            pref1_suf2 = L;
            break;                     // нашли наибольший, можно остановиться
        }
    }

    
    for (int L = maxL; L > 0; L--) 
    {
        int ok = 1;
        int start1 = len1 - L;         // начало суффикса в первой строке
        for (int i = 0; i < L; i++) 
        {
            if (s1[start1 + i] != s2[i]) 
            {
                ok = 0;
                break;
            }
        }
        if (ok) 
        {
            suf1_pref2 = L;
            break;                     // нашли наибольший, можно остановиться
        }
    }

    printf("%d %d\n", pref1_suf2, suf1_pref2);
    return 0;
}