/*-------------------------------------------------------------------
 * A0.c
 * ------------------------------------------------------------------
 * Сдать решение задачи A0-Максимум
 * ------------------------------------------------------------------
 * На стандартном потоке ввода задаётся натуральное число N (N > 0),
 * после которого следует последовательность из N целых чисел.
 * На стандартный поток вывода напечатайте, сколько раз в этой
 * последовательности встречается максимум.
 * Указание: использовать массивы запрещается.
 * -------------------------------------------------------------------
 * Формат входных данных
 * 5 целых чисел через пробел
 * -------------------------------------------------------------------
 * Формат результата
 * Одно единственное целое число
 * -------------------------------------------------------------------
 */
#include <stdio.h>

int main(void) {
    int N;			//Первое число = количесту чисел в чисел в воследовательности
    long long x ;          // текущее число
    long long max = 0;    // текущий максимум (значение не важно до первого числа)
    int count = 0;  // сколько раз встретился максимум
    //printf("Введите последовательность чисел:\n");
    // Считываем количество чисел N
    if (scanf("%d", &N) != 1 || N <= 0)
    {
        // Некорректный ввод N — выходим
        return 0;
    }

    // Цикл по всем N числам
    for (int i=0; i < N; i++)
    {
        // Считываем очередное число
        if (scanf("%lld", &x) != 1)
        {
            // Ошибка ввода — выходим
            return 0;
        }
        if (i == 0)
        {
            // Для самого первого элемента:
            // именно он становится начальным максимумом
            max = x;
            count = 1;
        }
        else
        {
            // Для всех последующих элементов сравниваем с текущим максимумом
            if (x > max)
            {
                // Нашли новый максимум
                max = x;
                count = 1;   // он встретился первый раз
            }
            else if (x == max)
            {
                // Число равно текущему максимуму
                count++;
            }
            // Если x < max — ничего не делаем
        }

    }

    // Выводим количество вхождений максимума
    printf("%d\n", count);
    return 0;
}
