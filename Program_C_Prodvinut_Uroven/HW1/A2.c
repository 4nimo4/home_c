/*-------------------------------------------------------------------
 * A1.c
 * ------------------------------------------------------------------
 * Циклический сдвиг
 * ------------------------------------------------------------------
 На вход программе подается беззнаковое 32-битное целое число N и 
 натуральное число K (1 ≤ K ≤ 31). Требуется циклически сдвинуть биты 
 числа N вправо на K битов и вывести полученное таким образом число.
 * -------------------------------------------------------------------
 * Формат входных данных
 * 
 * -------------------------------------------------------------------	
 * Формат результата
 * 
 * -------------------------------------------------------------------
 */
#include <stdio.h>
#include <inttypes.h>

// Циклический (кольцевой) сдвиг ВПРАВО 32‑битного числа n на rotate бит.
//
// Обычный сдвиг вправо (n >> k) отбрасывает младшие биты и дополняет
// слева нулями. ЦИКЛИЧЕСКИЙ сдвиг переносит "выпавшие" младшие биты
// в старшие разряды.
//
// Пример (для 8 бит):
//   n = abcdefgh
//   rightRotate(n, 2):
//     (n >> 2)       -> 00abcdef
//     (n << (8 - 2)) -> gh000000
//     ИЛИ (|)        -> ghabcdef
uint32_t rightRotate(uint32_t n, int rotate)
{
    // Нормализуем количество сдвигов по модулю 32:
    //  rotate & 31u == rotate % 32, но быстрее (31 = 0b11111).
    rotate &= 31u;

    if (rotate == 0)
        return n;   // сдвиг на 0 бит — число без изменений

    // (n >> rotate)        — обычный сдвиг вправо,
    //                         выпавшие младшие биты теряются.
    // (n << (32 - rotate)) — переносим эти выпавшие биты в старшие разряды.
    // Побитовое ИЛИ (|) объединяет обе части.
    return (n >> rotate) | (n << (32u - rotate));
}

int main(void)
{
    uint32_t N; // число, которое будем сдвигать
    int K; // величина сдвига

    //printf("Enter 32-bit unsigned integer (N): ");
    if (scanf("%" SCNu32, &N) != 1) 
    {
        printf("Input error\n");
        return 1;
    }

    //printf("Enter rotate count K (0..31): ");
    if (scanf("%" SCNu32, &K) != 1) 
    {
        printf("Input error\n");
        return 1;
    }

    uint32_t res = rightRotate(N, K);

    //printf("N = %d\n", N);
    //printf("K = %d\n", K);
    //printf("rotated = %d\n", res);
    printf("%u\n", res);
    return 0;
}