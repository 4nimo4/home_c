/*
//------------------------------------------------------
//  Дерево поиска 🌲🌳🌲
//------------------------------------------------------ 
Дерево поиска — это двоичное дерево, в
котором узлы упорядочены по значению
ключей. Для любого узла верно следующее
утверждение:
🎋 Значения ключей всех узлов его левого
поддерева меньше его значения
🎋 Значения ключей всех узлов его правого
поддерева больше его значения

//------------------------------------------------------
//  Поиск узла по ключу
//------------------------------------------------------ 
Ключи в двоичном дереве поиска хранятся с
соблюдением свойства упорядоченности.
На каждом шаге значение искомого узла
сравнивается со значением ключа в текущем
узле.
🎋 Если значение искомого узла меньше, то
переходим к левому поддереву
🎋 Если значение искомого узла больше, то
переходим к правому поддереву
🎋 Если значение равно, то ключ найден
🎋 Если поддерево пусто, то не найден

struct tree{
int key;
struct tree *left;
struct tree *right;
struct tree *parent; //позволяет двигаться вверх по дереву
}; 

//------------------------------------------------------
// Вопрос: Является бинарное дерево бинарным деревом поиска?
//------------------------------------------------------ 
                5
            1       4
                3       6
Дерево поиска — это двоичное дерево, в
котором узлы упорядочены по значению
ключей.
Для любого узла верно следующее
утверждение:
🎋 Значения ключей всех узлов его левого
поддерева меньше его значения
🎋 Значения ключей всех узлов его правого
поддерева больше его значения

Ответ: Не является!
//------------------------------------------------------ 
//Для самостоятельного разбора!
//------------------------------------------------------ 
typedef enum {false=0,true=1} bool;
bool isBST(tree* root)
{
    static tree *prev = NULL;
    // traverse the tree in inorder fashion and keep track of prev node
    if (root)
    {
        if (!isBST(root->left))
            return false;
            // Allows only distinct valued nodes
        if (prev != NULL && root->key <= prev->key)
            return false;
        prev = root;
        return isBST(root->right);
    }
    return true;
}
//------------------------------------------------------ 
//   Зачем нужно двоичное дерево поиска?
//------------------------------------------------------ 
                        8
                    3       10
                1       6       14
                    4       7  13        

Есть массив из чисел 8, 3, 10, 1, 6, 14, 4, 7, 13
🌲
🌲
🌲
Крайний левый элемент всегда
минимум, крайний правый максимум
Если идти направо от минимума, то
получим отсортированный массив по
возрастанию
Если идти налево от максимума, то
получим отсортированный массив по
убыванию
Количество сравнений нахождения
элемента в дереве в самом худшем виде
это высота дерева,
в массиве — длина массива

//------------------------------------------------------ 
//   Вставка нового узла
//------------------------------------------------------ 
Добавление нового ключа схоже с
поиском ключа.
🌴 Сначала надо найти место, куда
вставить ключ
🌴 Создать элемент
🌴 Прикрепить его
Для добавления нового узла удобно
использовать двойной указатель, т.к
может возникнуть ситуация, когда
дерево ещё пустое, и требуется
изменить его корень.
Сложность вставки аналогична поиску и
оценивается как O(h).
*/

#include <stdint.h>
#include <stdlib.h>
#include <stdio.h>

// Узел бинарного дерева поиска
typedef struct tree {
    int key;                 // ключ (значение), по которому строится дерево
    struct tree *left;       // указатель на левое поддерево
    struct tree *right;      // указатель на правое поддерево
    struct tree *parent;     // указатель на родителя (не обязателен, но полезен)
} tree;

//------------------------------------------------------
// Вычисление высоты дерева
// Высота пустого дерева = 0
// Высота непустого = max(высота левого, правого) + 1
//------------------------------------------------------
int heightTree(tree* p)
{
    if (p == NULL)
        return 0;  // пустое дерево или дошли до "низа"

    // вычисляем высоту каждого поддерева
    int lheight = heightTree(p->left);
    int rheight = heightTree(p->right);

    // возвращаем максимум + 1 за текущий узел
    if (lheight > rheight)
        return (lheight + 1);
    else
        return (rheight + 1);
}

//------------------------------------------------------
// Печать всех узлов на заданном уровне (level)
// level = 1 — печатаем текущий узел
// level > 1 — рекурсивно спускаемся в поддеревья, уменьшая level
//------------------------------------------------------
void printCurrentLevel(tree* root, int level)
{
    if (root == NULL)
        return;                 // нет узла — нечего печатать

    else if (level == 1)        // "дошли" до нужного уровня
        printf("%d ", root->key);

    else if (level > 1) 
    {
        // Сначала левое поддерево, потом правое.
        // Если поменять местами, порядок вывода внутри уровня изменится:
        // будет "справа налево" вместо "слева направо".
        printCurrentLevel(root->left,  level - 1);
        printCurrentLevel(root->right, level - 1);
    }
}

//------------------------------------------------------
// Обход дерева в ширину (BFS) через высоту и уровни
// Не классическая реализация через очередь, а через:
// 1) вычисление высоты дерева,
// 2) печать всех узлов на уровне 1, затем 2, 3, ...
//------------------------------------------------------
void printBFS(tree* root)
{
    int h = heightTree(root);         // высота дерева
    for (int i = 1; i <= h; i++)      // для каждого уровня
        printCurrentLevel(root, i);   // печатаем все узлы этого уровня
}

//------------------------------------------------------
// Симметричный обход (Inorder): Left, Root, Right
// Для бинарного дерева поиска даёт отсортированный вывод ключей.
// Пример: дерево из комментария: 3 2 4 1 5
//------------------------------------------------------
void inorder(tree *root)
{
    if (root == NULL)
        return;

    if (root->left)
        inorder(root->left);       // обходим левое поддерево

    printf("%d ", root->key);      // печатаем ключ текущего узла

    if (root->right)
        inorder(root->right);      // обходим правое поддерево
} 

//------------------------------------------------------
// Вставка ключа в бинарное дерево поиска
//  *root — адрес указателя на текущий узел (или корень),
//  key   — новый ключ для вставки,
//  pt    — родительский узел (чтобы заполнить поле parent).
//
// Если *root == NULL, создаём новый узел здесь.
// Иначе рекурсивно идём влево или вправо по правилу BST.
//------------------------------------------------------
void insert(tree **root, int key, tree *pt)
{
    if (!(*root)) {
        // Дерево пустое или дошли до "дыры" — создаём новый узел
        *root = calloc(1, sizeof(tree));  // память обнулена (left/right = NULL)
        (*root)->key    = key;            // записываем ключ
        (*root)->parent = pt;             // запоминаем родителя

        // С calloc строчка ниже не нужна: указатели уже равны NULL
        // (*root)->left = (*root)->right = NULL;
    }
    else if (key < (*root)->key)
        // Новый ключ меньше текущего — идём в левое поддерево
        insert(&((*root)->left), key, *root);
    else
        // Новый ключ >= текущего — идём в правое поддерево
        // (так ты обрабатываешь дубликаты: они уходят вправо)
        insert(&((*root)->right), key, *root);
}

//------------------------------------------------------
// main — построение дерева, обходы и демонстрация вставки
//------------------------------------------------------
int main(void)
{
    tree *tr = NULL;   // изначально дерево пустое

    // Строим дерево:
    //           10
    //        /      \
    //       5       15
    //     /  \     /  \
    //    3    7   13  18
    //   /        /
    //  1        6
    insert(&tr, 10, NULL);
    insert(&tr, 5,  NULL);
    insert(&tr, 15, NULL);
    insert(&tr, 3,  NULL);
    insert(&tr, 7,  NULL);
    insert(&tr, 13, NULL);
    insert(&tr, 18, NULL);
    insert(&tr, 1,  NULL);
    insert(&tr, 6,  NULL);

    // Обход в ширину по уровням до вставки нового элемента
    printf("BFS\n");
    printBFS(tr);
    printf("\n");

    // Симметричный обход (Inorder) до вставки
    printf("Inorder\n");
    inorder(tr);
    printf("\n");

    // Вставляем новый элемент 19 (пойдёт вправо от 18)
    insert(&tr, 19, NULL);

    // BFS после вставки 19
    printf("BFS\n");
    printBFS(tr);
    printf("\n");

    // Inorder после вставки 19 (порядок ключей остаётся отсортированным)
    printf("Inorder\n");
    inorder(tr);
    printf("\n");

    return 0;
}