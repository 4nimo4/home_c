/*
//------------------------------------------------------
//  Динамические структуры данных
//------------------------------------------------------ 
Типы рекурсивных данных, в которых содержится ссылка на
следующий и/или предыдущий элемент называют списками.
Рассмотрим различные варианты таких списков:
● Однонаправленный список без заглавного элемента
● Однонаправленный список с заглавным элементом
● Двунаправленный список без заглавного элемента
● Двунаправленный список с заглавным элементом
//------------------------------------------------------
//  Однонаправленный список без заглавного элемента
//------------------------------------------------------ 
Это такой типа данных, в котором каждое звено содержит ссылку на
следующее. При объявлении таких типов удобно использовать typedef.

typedef struct list {
uint32_t id;
struct list *next;
} list;

Внимание! Тип структуры не может иметь поля типа самой этой структуры, однако
допускаются указатели на тип самой структуры.

Рассмотрим пример списка из трёх звеньев, содержащий числа 1, 2, 3.
📜 Для создания каждого элемента предпочтительнее использовать calloc, так
как выделяемая память будет в этом случае инициализирована нулями и не
потребуется заносить NULL в конечный элемент списка.
📜 void * calloc( size_t number, size_t size );
📜 Важно помнить, что NULL обычно служит признаком конца списка.

            calloc                              `               malloc

head = calloc(1,sizeof(list));                          head = malloc(sizeof(list));
head->id = 1;                                           head->id = 1;

head->next = calloc(1,sizeof(list));                    head->next = malloc(sizeof(list));
head->next->id = 2;                                     head->next->id = 2;

head->next->next = calloc(1,sizeof(list));              head->next->next = malloc(sizeof(list));
head->next->next->id = 3;                               head->next->next->id = 3;
                                                        //Важно занести NULL в последний элемент 
                                                        head->next->next->next=NULL;
*/
#include <stdint.h>   // заголовок с определениями целочисленных типов фиксированного размера (uint32_t и др.)
#include <stdlib.h>   // заголовок с функциями работы с памятью (malloc, calloc, free и др.)
#include <stdio.h>    // заголовок с функциями ввода-вывода (printf и др.)

// Определение структуры одного элемента однонаправленного списка
typedef struct list 
{
    uint32_t id;        // поле данных: целое без знака (идентификатор/значение узла)
    struct list *next;  // указатель на следующий элемент списка (или NULL, если элемент последний)
} list;                 // псевдоним: теперь можно писать просто "list" вместо "struct list"
//------------------------------------------------------
//  Печать однонаправленного списка
//------------------------------------------------------ 
/*
При работе со списком удобно описать соответствующие обслуживающие
функции (например, печать, добавление, удаление и т.п.)
и затем пользоваться ими в программе.
*/

// Итерационная печать списка - но в этом случае мы изменяем указатель параметра *p
void printListIteration1(list *p)
{
    // Цикл проходит по всем элементам списка, пока указатель p не станет NULL (конец списка)
    for(; p != NULL; p = p->next)      // на каждой итерации переходим к следующему элементу: p = p->next
        printf("%d ", p->id);          // печатаем значение поля id текущего элемента
    printf("\n");                      // в конце печатаем перевод строки
}

// Итерационная печать - эта же функция, но через отдельный указатель ptr - так лучше
void printListIteration2(list *p)
{
    // Здесь исходный указатель p не меняется, мы используем локальный указатель ptr
    for(list *ptr = p; ptr != NULL; ptr = ptr->next)  // ptr «бежит» по списку
        printf("%d ", ptr->id);       // печатаем значение поля id текущего элемента
    printf("\n");                     // в конце печатаем перевод строки
}

// Рекурсивная печать списка
void printListRecurs(list *p)
{
    if (p)                            // если текущий элемент существует (p != NULL)
    {
        printf("%d ", p->id);         // печатаем поле id текущего элемента
        printListRecurs(p->next);     // рекурсивно печатаем оставшуюся часть списка, начиная со следующего элемента
    }
    else                              // если p == NULL, то достигнут конец списка
        printf("\n");                 // печатаем перевод строки и выходим из рекурсии
}
//-----------------------------------------------------

int main(void)
{
    list* head = NULL;                // указатель на первый элемент списка (голова); изначально список пуст (NULL)

    // Создаём первый элемент списка.
    // calloc выделяет память под 1 объект размера sizeof(list)
    // и обнуляет всю выделенную память (все поля, включая next, будут нулями/NULL).
    head = calloc(1, sizeof(list));   // при успешном выделении память под первый узел списка
    // head = malloc(sizeof(list));   // альтернатива: malloc выделяет память, но НЕ обнуляет её (поля имеют неопределённые значения)

    head->id = 10;                    // записываем в поле id первого элемента значение 10

    // Создаём второй элемент списка и соединяем его с первым.
    head->next = calloc(1, sizeof(list));  // выделяем и обнуляем память под второй элемент
    // head->next = malloc(sizeof(list));  // при использовании malloc память не инициализируется
    head->next->id = 12;                   // записываем значение 12 во второй элемент

    // Создаём третий элемент списка и соединяем его со вторым.
    head->next->next = calloc(1, sizeof(list)); // выделяем и обнуляем память под третий элемент
    // head->next->next = malloc(sizeof(list));  // аналогично, только без обнуления
    head->next->next->id = 3;                  // записываем значение 3 в третий элемент

    // Если делаем через malloc - важно занести NULL в поле next последнего элемента
    // иначе указатель будет содержать мусор, и обход списка может привести к ошибке.
    // head->next->next->next = NULL;         // вручную помечаем конец списка (если использовали malloc)

    // Проверочный вывод (закомментирован): напечатать значения трёх элементов напрямую
    // printf("%d %d %d\n", head->id, head->next->id, head->next->next->id);

    // Выводим список тремя разными способами:
    printListIteration1(head);        // итеративный вывод с изменением параметра p
    printListIteration2(head);        // итеративный вывод через локальный указатель ptr
    printListRecurs(head);            // рекурсивный вывод

    // Здесь хорошо бы освободить всю выделенную память (free),
    // но в данной учебной программе это опущено.

    return 0;                         // успешное завершение программы
}