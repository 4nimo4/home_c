/*
//------------------------------------------------------
//  Динамические структуры данных
//------------------------------------------------------ 
//  Однонаправленный список с заглавным звеном
//------------------------------------------------------ 
Часто для облегчения операций добавления и удаления звеньев в списки
используют списки с заглавным звеном.
📜 В заглавном звене не хранят никаких данных. но можно здесь хранить количество
элементов в списке - (добавляем +1, удаляем -1)
📜 Для списка с заглавным звеном указатель на его начало никогда не
изменяется, это удобно при передаче такого списка в функцию в качестве
указателя.

// Добавляем заглавное звено
list* L = calloc(1,sizeof(list));
// Эти данные не используются
L->id = -1;


*/
#include <stdint.h>   // заголовок с определениями целочисленных типов фиксированного размера (uint32_t и др.)
#include <stdlib.h>   // заголовок с функциями работы с памятью (malloc, calloc, free и др.)
#include <stdio.h>    // заголовок с функциями ввода-вывода (printf и др.)

// Определение структуры одного элемента однонаправленного списка
typedef struct list 
{
    uint32_t id;        // поле данных: целое без знака (идентификатор/значение узла)
    struct list *next;  // указатель на следующий элемент списка (или NULL, если элемент последний)
} list;                 // псевдоним: теперь можно писать "list" вместо "struct list"
//------------------------------------------------------
//  Печать однонаправленного списка
//------------------------------------------------------ 
/*
При работе со списком удобно описать соответствующие обслуживающие
функции и в дальнейшем использовать их в программе.
*/
// Итерационная печать - но в этом случае мы "ломаем" (изменяем) указатель *p
void printListIteration1(list *p)
{
    // Цикл проходит по всем элементам списка, пока указатель p не станет NULL
    for(; p != NULL; p = p->next)     // на каждой итерации p переходит на следующий узел
        printf("%d ", p->id);         // печатаем значение поля id текущего элемента
    printf("\n");                     // после завершения цикла печатаем перевод строки
}

// Итерационная печать - та же логика, но через отдельный указатель ptr - так лучше
void printListIteration2(list *p)
{
    // Здесь исходный указатель p не изменяется, используем локальный указатель ptr
    for(list *ptr = p; ptr != NULL; ptr = ptr->next)  // ptr «бежит» по списку
        printf("%d ", ptr->id);       // печатаем значение поля id текущего элемента
    printf("\n");                     // в конце печатаем перевод строки
}

// Рекурсивная печать
void printListRecurs(list *p)
{
    if(p)                             // если текущий узел существует
    {
        printf("%d ", p->id);         // печатаем его значение
        printListRecurs(p->next);     // рекурсивно вызываем для следующего узла
    }
    else                              // если p == NULL — достигнут конец списка
        printf("\n");                 // печатаем перевод строки
}
//------------------------------------------------------ 
// Добавление звена в начало списка без заглавного элемента. Вариант 1
//------------------------------------------------------ 
void insert1(list **head, int32_t value) 
{
    // Выделяем память под новый элемент и обнуляем её
    list *new = calloc(1, sizeof(list));
    new->id = value;        // записываем значение в поле id
    new->next = *head;      // новый элемент указывает на прежнюю голову списка
    *head = new;            // голова списка теперь указывает на новый элемент
}
//------------------------------------------------------ 
// Добавление звена в начало списка без заглавного элемента. Вариант 2
//------------------------------------------------------ 
list* insert2(list *head, int32_t value) 
{
    list *new = calloc(1, sizeof(list));  // создаём новый элемент
    new->id = value;                      // записываем значение
    new->next = head;                     // новый элемент указывает на старую голову
    return new;                           // возвращаем новый указатель на голову списка
}
//------------------------------------------------------ 
// Добавление звена в начало списка с заглавным элементом
//------------------------------------------------------ 
// С заглавным элементом двойной указатель не нужен: сам заголовок всегда существует
void insert3(list *head, int32_t value) 
{
    list *new = calloc(1, sizeof(list)); // создаём новый элемент
    new->id = value;                     // записываем значение
    new->next = head->next;              // новый элемент будет стоять сразу после заголовка
    head->next = new;                    // заголовок теперь указывает на новый элемент
    // предполагается, что в списке есть хотя бы одно звено или оно будет добавлено первым
}
//------------------------------------------------------ 
// Добавление звена в конец списка без заглавного элемента
// с использованием двойного указателя
//------------------------------------------------------ 
void insert_end1(list **head, int32_t value) 
{
    list *new = calloc(1, sizeof(list)); // создаём новый элемент
    new->id = value;                     // записываем значение
    // new->next уже равен NULL благодаря calloc

    if (*head == NULL) {        // пустой список: голова ещё не указывает ни на один элемент
        *head = new;            // делаем новый элемент головой списка
    } 
    else {
        list *p = *head;        // начинаем обход с первого элемента
        while (p->next != NULL) // пока не дойдём до последнего элемента
            p = p->next;        // переходим к следующему узлу
        p->next = new;          // «подвешиваем» новый элемент в конец списка
    }
}
//------------------------------------------------------ 
// Добавление звена в конец списка без заглавного элемента
// и без двойного указателя (голова возвращается как результат)
//------------------------------------------------------ 
list* insert_end2(list *head, int32_t value) 
{
    list *new = calloc(1, sizeof(list)); // создаём новый элемент
    new->id = value;                     // записываем значение

    if (head == NULL) {     // пустой список
        return new;         // новый элемент становится головой
    } 
    else {
        list *p = head;     // начинаем с текущей головы
        while (p->next != NULL)
            p = p->next;    // идём до последнего элемента
        p->next = new;      // добавляем новый элемент в конец
        return head;        // голова списка не меняется, возвращаем её
    }
}
//------------------------------------------------------ 
// Добавление звена в конец списка без заглавного элемента
// рекурсивный вариант
//------------------------------------------------------ 
void insert_end_recurs(list **head, int32_t value) 
{
    if (*head == NULL)      // базовый случай: пустое место (хвост списка/пустой список)
    {
        (*head) = calloc(1, sizeof(list)); // создаём новый элемент
        (*head)->id = value;               // записываем значение
        // next уже равен NULL из-за calloc
    } 
    else {
        // рекурсивно переходим к следующему указателю next
        // пока не найдем место, где *head == NULL
        insert_end_recurs(&((*head)->next), value);
    }
}
//------------------------------------------------------ 
// Добавление звена в конец списка с заглавным элементом
// head — указатель на заглавный элемент (НЕ NULL)
//------------------------------------------------------ 
void insert_end_3(list *head, int32_t value)
{
    list *new = calloc(1, sizeof(list)); // создаём новый элемент
    if (!new)                            // проверяем успешность выделения памяти
        return;                          // при ошибке просто выходим (в реальной программе — обработать ошибку)

    new->id = value;                     // записываем значение
    new->next = NULL;                    // этот элемент станет последним

    // идём от заголовка до последнего реального узла
    list *p = head;
    while (p->next != NULL)             // пока есть следующий элемент
        p = p->next;                    // двигаемся дальше

    p->next = new;                      // прицепляем новый элемент в конец списка
}
//-----------------------------------------------------

int main(void)
{
    //-----------------------------------------------------
    // Добавление звена в начало списка без заглавного элемента. Вариант 1
    //-----------------------------------------------------
    list* L = NULL;          // изначально список пуст
    insert1(&L, 1);          // список: 1
    insert1(&L, 2);          // список: 2 -> 1
    insert1(&L, 3);          // список: 3 -> 2 -> 1
   
    printListIteration1(L);  // вывод: 3 2 1 
    printListIteration2(L);  // вывод: 3 2 1 
    printListRecurs(L);      // вывод: 3 2 1 

    //-----------------------------------------------------
    // Добавление звена в начало списка без заглавного элемента. Вариант 2
    //-----------------------------------------------------
    L = NULL;                // очищаем (начинаем новый список)
    L = insert2(L, 5);       // список: 5
    L = insert2(L, 2);       // список: 2 -> 5
    L = insert2(L, 1);       // список: 1 -> 2 -> 5
   
    printListIteration1(L);  // вывод: 1 2 5 
    printListIteration2(L);  // вывод: 1 2 5 
    printListRecurs(L);      // вывод: 1 2 5 

    //-----------------------------------------------------
    // Добавление звена в начало списка с заглавным элементом
    //-----------------------------------------------------
    L = calloc(1, sizeof(list)); // создаём заглавное (служебное) звено
    L->id = -1;                  // данные заголовка не используются в логике
    insert3(L, 7);               // список: -1 (head) -> 7
    insert3(L, 8);               // список: -1 -> 8 -> 7
    insert3(L, 6);               // список: -1 -> 6 -> 8 -> 7
   
    printListIteration1(L);      // вывод: -1 6 8 7 
    printListIteration2(L);      // вывод: -1 6 8 7 
    printListRecurs(L);          // вывод: -1 6 8 7 

    //------------------------------------------------------ 
    // Добавление звена в конец списка без заглавного элемента
    // с использованием двойного указателя
    //------------------------------------------------------ 
    L = NULL;                    // новый список
    insert_end1(&L, 9);          // список: 9
    insert_end1(&L, 11);         // список: 9 -> 11
    insert_end1(&L, 10);         // список: 9 -> 11 -> 10
   
    printListIteration1(L);      // вывод: 9 11 10 
    printListIteration2(L);      // вывод: 9 11 10 
    printListRecurs(L);          // вывод: 9 11 10 

    //------------------------------------------------------ 
    // Добавление звена в конец списка без заглавного элемента
    // и без двойного указателя
    //------------------------------------------------------ 
    L = NULL;                    // новый список
    L = insert_end2(L, 12);      // список: 12
    L = insert_end2(L, 14);      // список: 12 -> 14
    L = insert_end2(L, 13);      // список: 12 -> 14 -> 13
   
    printListIteration1(L);      // вывод: 12 14 13 
    printListIteration2(L);      // вывод: 12 14 13 
    printListRecurs(L);          // вывод: 12 14 13 

    //------------------------------------------------------ 
    // Добавление звена в конец списка без заглавного элемента
    // рекурсивный вариант
    //------------------------------------------------------ 
    L = NULL;                       // новый список
    insert_end_recurs(&L, 15);      // список: 15
    insert_end_recurs(&L, 17);      // список: 15 -> 17
    insert_end_recurs(&L, 16);      // список: 15 -> 17 -> 16
   
    printListIteration1(L);         // вывод: 15 17 16 
    printListIteration2(L);         // вывод: 15 17 16  
    printListRecurs(L);             // вывод: 15 17 16  

    //------------------------------------------------------ 
    // Добавление звена в конец списка с заглавным элементом
    //------------------------------------------------------ 
    // L = NULL;                    // можно было бы обнулить, но ниже мы всё равно пересоздаём L
    L = calloc(1, sizeof(list));    // создаём заглавное звено
    L->id = -1;                     // данные заголовка не используются
    insert_end_3(L, 18);            // список: -1 -> 18
    insert_end_3(L, 20);            // список: -1 -> 18 -> 20
    insert_end_3(L, 19);            // список: -1 -> 18 -> 20 -> 19
   
    printListIteration1(L);         // ФАКТИЧЕСКИ: -1 18 20 19 (в комментарии в исходнике были старые числа)
    printListIteration2(L);         // -1 18 20 19  
    printListRecurs(L);             // -1 18 20 19  
    // если не печатать заголовок — печатаем, начиная с первого реального элемента
    printListIteration1(L->next);   // вывод: 18 20 19
    //-----------------------------------------------------

    return 0;                       // успешное завершение программы
}