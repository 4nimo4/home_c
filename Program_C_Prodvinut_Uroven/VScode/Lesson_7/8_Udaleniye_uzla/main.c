/*
//------------------------------------------------------
//  Удаление узла
//------------------------------------------------------ 
При удалении узла могут возникнуть три различных ситуации:
🌴 Узел не имеет потомков. В этом случае происходит его удаление. В
родительский элемент добавляется нулевой указатель
🌴 Узел имеет одного потомка. В данном случае узел удаляется, а его потомок
переходит к родителю
🌴 Узел имеет два потомка. В этом случае необходимо найти минимальный
элемент в правом поддереве
Сложность удаления элемента из дерева оценивается как O(h), даже если при
удалении придётся искать последователя удаляемого элемента.

                                10
                        5               15
                     3     7          13   18
                   1      6

//------------------------------------------------------
//  Узел не имеет потомков - узел является листом
//------------------------------------------------------
   Удаляем 1 - В данном случае узел удаляется и узел с ключом 3
                        становится пустым.

//------------------------------------------------------
//  Узел имеет только одного сына
//------------------------------------------------------
   Удаляем 3 - В данном случае сын удаляемого узла 3 переходит к его
                        родителю - узлу 5.

//------------------------------------------------------
//  Узел имеет два сына
//------------------------------------------------------
   Удаляем 5 - 🌳 Необходимо найти минимальный элемент в правом дереве. 
                        Узел с ключом 6.
                🌳 Переносим ключ из узла 6 в узел с ключом 5.
                🌳 Сводим задачу к удалению узла с ключом 6.

*/

#include <stdint.h>   // фиксированные целочисленные типы (int32_t и др.)
#include <stdlib.h>   // функции работы с памятью (malloc, calloc, free)
#include <stdio.h>    // ввод-вывод (printf и др.)

// Узел бинарного дерева поиска
typedef struct tree {
    int key;                 // Ключ (значение) узла
    struct tree *left;       // Указатель на левое поддерево
    struct tree *right;      // Указатель на правое поддерево
    struct tree *parent;     // Указатель на родительский узел
} tree;

//------------------------------------------------------
// Вычисление высоты дерева
//------------------------------------------------------
int heightTree(tree* p)
{
    if (p == NULL)
        return 0;  // Высота пустого дерева = 0
    else 
    {
        // Рекурсивно вычисляем высоту левого и правого поддеревьев
        int lheight = heightTree(p->left);
        int rheight = heightTree(p->right);

        // Высота текущего дерева = максимум(высота левого, высота правого) + 1 (за текущий узел)
        if (lheight > rheight)
            return (lheight + 1);
        else
            return (rheight + 1);
    }
}

//------------------------------------------------------
// Печать всех узлов на заданном уровне (для обхода в ширину)
// level = 1 означает «печатаем этот узел»
//------------------------------------------------------
void printCurrentLevel(tree* root, int level)
{
    if (root == NULL)
        return;         // Нечего печатать (пустой указатель)

    else if (level == 1)  // Мы «спустились» ровно на нужный уровень
        printf("%d ", root->key);   // Печатаем ключ текущего узла

    else if (level > 1) 
    {
        // Уменьшаем level и рекурсивно спускаемся:
        // сначала в левое, потом в правое поддерево
        printCurrentLevel(root->left, level - 1);
        printCurrentLevel(root->right, level - 1);
    }
}

//------------------------------------------------------
// Обход дерева в ширину (BFS) через уровни
// Реализован не через очередь, а через:
//   1) вычисление высоты,
//   2) печать уровней один за другим.
//------------------------------------------------------
void printBFS(tree* root)
{
    int h = heightTree(root);        // высота дерева
    for (int i = 1; i <= h; i++)     // для каждого уровня от 1 до h
        printCurrentLevel(root, i);  // печатаем все узлы этого уровня
}

//------------------------------------------------------
// Симметричный обход (Inorder): Left, Root, Right
// Для бинарного дерева поиска даёт отсортированный вывод ключей.
//------------------------------------------------------
void inorder(tree *root)
{
    if (root == NULL)
        return;                      // пустое поддерево

    if (root->left)
        inorder(root->left);         // сначала левое поддерево

    printf("%d ", root->key);        // затем сам узел

    if (root->right)
        inorder(root->right);        // затем правое поддерево
} 

//------------------------------------------------------
// Вставка ключа в бинарное дерево поиска
//   root — адрес указателя на корень (или на текущий подузел),
//   key  — добавляемый ключ,
//   pt   — указатель на родителя (для заполнения поля parent).
//
// Если *root == NULL, создаём новый узел в этом месте.
// Иначе рекурсивно спускаемся влево или вправо.
//------------------------------------------------------
void insert(tree **root, int key, tree *pt)
{
    if (!(*root)) {
        // Дошли до пустого места — создаём новый узел
        *root = calloc(1, sizeof(tree));  // память обнулена (left/right = NULL)
        (*root)->key = key;               // записываем ключ
        (*root)->parent = pt;             // устанавливаем указатель на родителя
        // left и right уже равны NULL
    }
    else if (key < (*root)->key)
        // Ключ меньше текущего — идём в левое поддерево
        insert(&((*root)->left), key, *root);
    else
        // Ключ больше или равен — идём в правое поддерево
        // (дубликаты ключей помещаем вправо)
        insert(&((*root)->right), key, *root);
}

//------------------------------------------------------
// Рекурсивный поиск ключа в дереве поиска
// Возвращает указатель на узел с заданным ключом или NULL,
// если такого ключа нет.
//------------------------------------------------------
tree* search_tree(tree *root, int32_t key)
{
    // Базовый случай: дошли до NULL или нашли нужный ключ
    if (root == NULL || root->key == key)
        return root;

    // Если искомый ключ меньше текущего — ищем в левом поддереве
    else if (root->key > key)
        return search_tree(root->left, key);

    // Иначе — ищем в правом поддереве
    else
        return search_tree(root->right, key);
}

//------------------------------------------------------
// Итеративный поиск ключа в дереве поиска
// Аналог search_tree, но без рекурсии.
//------------------------------------------------------
tree* search_tree_i(tree *root, int key)
{  
    tree *find = root;   // начинаем поиск с корня

    // Пока не дошли до NULL и не нашли ключ
    while (find && find->key != key) 
    {
        if (key < find->key)
            find = find->left;   // идём влево
        else
            find = find->right;  // идём вправо
    }
    // либо нашли узел (find->key == key), либо find == NULL
    return find;
}

//------------------------------------------------------
// Доп. рекурсивный поиск (по сути то же самое, что search_tree)
//------------------------------------------------------
tree * searchKey(tree *root, int key) {
    if (!root)
        return NULL;                // пустое поддерево
    if (root->key == key)
        return root;                // нашли нужный ключ
    if (key < root->key )
        return searchKey(root->left, key);   // ищем слева
    return searchKey(root->right, key);      // иначе ищем справа
}

//------------------------------------------------------
// Поиск минимального по ключу узла в поддереве
// (самый левый узел)
//------------------------------------------------------
tree* min_tree(tree *root) {
    tree *find = root;
    while (find && find->left)      // идём до самого левого узла
    {
        find = find->left;
    }
    return find;                    // либо минимальный узел, либо NULL
}

//------------------------------------------------------
// Поиск узла-«последователя» (inorder successor):
// узел с минимальным ключом, который больше ключа root.
//------------------------------------------------------
/*
Если правое поддерево текущего узла не пусто, то последователем
будет самый левый узел его правого поддерева (минимальный ключ справа).
Если правого поддерева нет, поднимаемся вверх по parent, пока
не найдём узел, для которого текущий узел лежит в левом поддереве.
*/
tree* left_follower_key(tree *root) 
{
    if (root == NULL)
        return root;        // пустой указатель — нет последователя

    if (root->right)
        // Если есть правое поддерево, последователь — минимум справа
        return min_tree(root->right);
    else 
    {
        // Идём вверх по parent
        tree *y = root->parent; // потенциальный предок
        tree *x = root;         // текущий узел
        // Поднимаемся, пока идём по правым веткам
        while (y && x == y->right) 
        {
            x = y;
            y = y->parent;
        }
        // Либо нашли предка, в чьём левом поддереве лежит исходный узел,
        // либо дошли до вершины (y == NULL) и последователя нет.
        return y;
    }
}

//------------------------------------------------------
// Удаление узла из двоичного дерева поиска
// root — корень дерева (по значению),
// pt   — указатель на удаляемый узел.
// Функция возвращает указатель на фактически удалённый элемент.
//------------------------------------------------------
tree* delete(tree **root, tree* pt) 
{
    tree *remove = NULL, *remove_son;

    // Если у pt нет детей или только один ребёнок — удаляем сам pt
    if (pt->left == NULL || pt->right == NULL)
        remove = pt;
    else
        // Если у pt два потомка — удаляем его «последователя»
        // (узел со следующим по величине ключом).
        // У последователя не может быть левого сына, только один (правый) потомок.
        remove = left_follower_key(pt); // Всегда только один (или ни одного) потомок

    // Прикрепляем потомка удаляемого элемента к родителю,
    // либо делаем этого потомка корнем дерева
    if (remove->left != NULL)       // если есть левый ребёнок (для случая, когда remove — не последователь)
        remove_son = remove->left;
    else
        remove_son = remove->right; // иначе берём правого (или NULL, если детей нет)

    if (remove_son)                 // если потомок существует — обновляем его parent
        remove_son->parent = remove->parent;

    if (remove->parent == NULL)     // если удаляем корень всего дерева
        *root = remove_son;          // новый корень — его потомок
    else if (remove == remove->parent->left)
        remove->parent->left = remove_son;   // удаляемый узел был левым ребёнком
    else
        remove->parent->right = remove_son;  // удаляемый узел был правым ребёнком

    // Если удаляем не сам pt (а его последователя), то переносим значение
    // ключа последователь в исходный узел pt.
    if (pt != remove)
        pt->key = remove->key;

    return remove;                  // возвращаем фактически удалённый узел (его можно free)
}

//------------------------------------------------------
// main — создание дерева, печать, поиск, удаление
//------------------------------------------------------
int main(void)
{
    tree *tr = NULL; // пустое дерево (корень = NULL)

    // Строим дерево поиска вставками
    insert(&tr, 10, NULL);
    insert(&tr, 5,  NULL);
    insert(&tr, 15, NULL);
    insert(&tr, 3,  NULL);
    insert(&tr, 7,  NULL);
    insert(&tr, 13, NULL);
    insert(&tr, 18, NULL);
    insert(&tr, 1,  NULL);
    insert(&tr, 6,  NULL);

    printf("\nBFS\n");
    printBFS(tr);       // печать дерева по уровням
    printf("\n");

    printf("Inorder\n");
    inorder(tr);        // печать (Inorder) — ключи по возрастанию
    printf("\n");

    // Добавим новый элемент (8)
    insert(&tr, 8, NULL);

    printf("BFS\n");
    printBFS(tr);       // снова печать в ширину (теперь с 8)
    printf("\n");

    printf("Inorder\n");
    inorder(tr);        // снова Inorder
    printf("\n");

    // Поиск ключа 7 (рекурсивная версия)
    tree *node = search_tree(tr, 7);
    if (node)
        printf("\nsearch_tree(дерево поиска) = %d\n", node->key);
    else
        printf("\nNO\n");

    // Поиск ключа 7 (итеративная версия)
    node = search_tree_i(tr, 7);
    if (node)
        printf("\nsearch_tree_i (дерево поиска итеративная версия) = %d\n", node->key);
    else
        printf("\nNO_i\n");

    // Если нашли узел (node от итеративного поиска),
    // печатаем поддерево с этим узлом как корнем (Inorder)
    if (node)
    {
        printf("\nПоддерево в порядке убывания из найденного узла:\n");
        inorder(node);
        printf("\n");
    }
    else
        printf("\nNO\n");

    //------------------------------------------------------
    // Пример удаления узла в двоичном дереве поиска
    //------------------------------------------------------
    printf("\nНашли поддерево с ключом 5:\n");
    printBFS(searchKey(tr, 5));  // печатаем поддерево, где корень — узел с ключом 5
    printf("\n");
    tree *del = NULL;
    del = delete(&tr, searchKey(tr, 5)); // удаляем узел с ключом 5
    free(del);                          // освобождаем память удалённого узла
    printf("\nВсе дерево в которм удалили ключ 5:\n");
    inorder(tr);                        // печатаем дерево после удаления (Inorder)
    printf("\n");

    return 0;
}