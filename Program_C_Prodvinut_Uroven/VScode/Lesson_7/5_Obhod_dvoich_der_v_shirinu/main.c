/*
//------------------------------------------------------
//  Обходы двоичных деревьев 🌲🌳🌲
//------------------------------------------------------ 
//  Обход в ширину BFS (Breadth First Traversal)
//------------------------------------------------------ 
дерево:

                1                    
            2       5               
        3       4                                   

-> 1 ->
-> 2 -> 5 ->
-> 3 -> 4

int heightTree(tree* p){
    //1. Вычисляем высоту дерева
}
void printCurrentLevel(tree* root, int level){
    //2. Печатаем все узлы на уровне level
}
void printBFS(tree* root){
    //3. Функция печати
}

Для этого алгоритма удобно использовать две функции. Одна из которых 
печатает узлы на определённом уровне, вторая обходит все уровни дерева. 
Для исходного дерева вывод будет: 1 2 5 3 4.
*/

#include <stdint.h>
#include <stdlib.h>
#include <stdio.h>

// Узел бинарного дерева
typedef struct tree {
    int key;                 // значение (ключ) узла
    struct tree *left;       // указатель на левое поддерево
    struct tree *right;      // указатель на правое поддерево
    struct tree *parent;     // указатель на родителя (в этом примере не используется)
} tree;

//------------------------------------------------------
// Вычисление высоты дерева
// Высота пустого дерева = 0
// Высота непустого = max(высота левого, правого) + 1
//------------------------------------------------------
int heightTree(tree* p)
{
    if (p == NULL)
        return 0;  // если узла нет — высота 0
    else 
    {
        // рекурсивно вычисляем высоту каждого поддерева
        int lheight = heightTree(p->left);
        int rheight = heightTree(p->right);

        // высота — максимум из двух высот + 1 за текущий узел
        if (lheight > rheight)
            return (lheight + 1);
        else
            return (rheight + 1);
    }
}

//------------------------------------------------------
// Печать всех узлов на заданном уровне (level)
// level = 1 — печатаем текущий узел
// level > 1 — рекурсивно спускаемся влево и вправо, уменьшая level
//------------------------------------------------------
void printCurrentLevel(tree* root, int level)
{
    if (root == NULL)
        return;                 // нет узла — нечего печатать

    else if (level == 1)        // «дошли» до нужного уровня
        printf("%d ", root->key);

    else if (level > 1) 
    {
        // Сначала левое поддерево, потом правое.
        // Если поменять вызовы местами, порядок вывода
        // внутри уровня изменится (справа налево).
        printCurrentLevel(root->left,  level - 1);
        printCurrentLevel(root->right, level - 1);
    }
}

//------------------------------------------------------
// Обход дерева в ширину (BFS) через уровни
// 1) находим высоту дерева,
// 2) для каждого уровня от 1 до h печатаем все узлы этого уровня.
//------------------------------------------------------
void printBFS(tree* root)
{
    int h = heightTree(root);        // высота дерева

    // Для каждого уровня вызываем printCurrentLevel
    for (int i = 1; i <= h; i++)
        printCurrentLevel(root, i);
}

//------------------------------------------------------
// main — ручная сборка конкретного дерева и обход BFS
//------------------------------------------------------
int main(void)
{
    tree *tr = NULL;

    // Создаём корень
    tr = calloc(1, sizeof(tree));
    tr->key = 1;

    // Правый потомок корня
    tr->right = calloc(1, sizeof(tree));
    tr->right->key = 5;

    // Левый потомок корня
    tr->left = calloc(1, sizeof(tree));
    tr->left->key = 2;

    // Левый потомок узла с ключом 2
    tr->left->left = calloc(1, sizeof(tree));
    tr->left->left->key = 3;

    // Правый потомок узла с ключом 2
    tr->left->right = calloc(1, sizeof(tree));
    tr->left->right->key = 4;

    /*
        Получившееся дерево:

                 1
               /   \
              2     5
             / \
            3   4

        Уровни:
        уровень 1:          1
        уровень 2:        2   5
        уровень 3:       3 4

        Обход в ширину (BFS) по уровням: 1 2 5 3 4
    */

    printf("BFS\n");      // ожидаемый вывод: 1 2 5 3 4
    printBFS(tr);
    printf("\n");

    return 0;
}