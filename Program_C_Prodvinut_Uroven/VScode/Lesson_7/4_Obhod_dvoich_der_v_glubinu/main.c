/*
//------------------------------------------------------
//  Обходы двоичных деревьев 🌲🌳🌲
//------------------------------------------------------ 
//  Обходы в глубину DFS (Depth First Traversals)
//------------------------------------------------------ 
дерево:

                1                       A           A,B,C - Preorder
            2       5               B       C       B,A,C - Inorder
        3       4                                   B,C,A - Postorder

Существуют различные способы обхода двоичных деревьев.
Рассмотрим их на примере дерева:
🌲 Preorder (Root, Left, Right) : 1 2 3 4 5
🌲 Inorder (Left, Root, Right) : 3 2 4 1 5
🌲 Postorder (Left, Right, Root) : 3 4 2 5 1

Отличаются только размещением строчки printf("%d ",root->key); внутри функции

*/

#include <stdint.h>
#include <stdlib.h>
#include <stdio.h>

// Узел бинарного дерева
typedef struct tree {
    int key;                 // значение (ключ) узла
    struct tree *left;       // указатель на левое поддерево
    struct tree *right;      // указатель на правое поддерево
    struct tree *parent;     // указатель на родителя (здесь не используется)
} tree;

//------------------------------------------------------
// Preorder (Root, Left, Right)
// Обход в глубину в порядке: корень, левое поддерево, правое поддерево.
// Для дерева:
//          1
//        /   \
//       2     5
//      / \
//     3   4
// порядок будет: 1 2 3 4 5
//------------------------------------------------------
void preorder(tree *root)
{
    if (root == NULL)
        return;                     // пустой поддерево — выходим

    // 1. Сначала обрабатываем (печатаем) текущий узел — Root
    printf("%d ", root->key);

    // 2. Рекурсивно обходим левое поддерево — Left
    if (root->left)
        preorder(root->left);

    // 3. Рекурсивно обходим правое поддерево — Right
    if (root->right)
        preorder(root->right);
}

//------------------------------------------------------
// Inorder (Left, Root, Right)
// Симметричный обход: левое поддерево, корень, правое поддерево.
// Для бинарного дерева поиска даёт отсортированный вывод ключей.
// Для данного дерева порядок: 3 2 4 1 5
//------------------------------------------------------
void inorder(tree *root)
{
    if (root == NULL)
        return;

    // 1. Сначала левое поддерево — Left
    if (root->left)
        inorder(root->left);

    // 2. Затем сам узел — Root
    printf("%d ", root->key);

    // 3. В конце — правое поддерево — Right
    if (root->right)
        inorder(root->right);
}

//------------------------------------------------------
// Postorder (Left, Right, Root)
// Обход: левое поддерево, правое поддерево, корень.
// Часто используется для удаления дерева (free снизу вверх).
// Для нашего дерева: 3 4 2 5 1
//------------------------------------------------------
void postorder(tree *root)
{
    if (root == NULL)
        return;

    // 1. Сначала левое поддерево — Left
    if (root->left)
        postorder(root->left);

    // 2. Затем правое поддерево — Right
    if (root->right)
        postorder(root->right);

    // 3. И только потом — корень — Root
    printf("%d ", root->key);
}

//------------------------------------------------------
// main — вручную создаём дерево и демонстрируем три обхода DFS
//------------------------------------------------------
int main(void)
{
    tree *tr = NULL;

    // Создаём корень
    tr = calloc(1, sizeof(tree));
    tr->key = 1;

    // Правый потомок корня
    tr->right = calloc(1, sizeof(tree));
    tr->right->key = 5;

    // Левый потомок корня
    tr->left = calloc(1, sizeof(tree));
    tr->left->key = 2;

    // Левый потомок узла 2
    tr->left->left = calloc(1, sizeof(tree));
    tr->left->left->key = 3;

    // Правый потомок узла 2
    tr->left->right = calloc(1, sizeof(tree));
    tr->left->right->key = 4;

    /*
        Получившееся дерево:

                 1
               /   \
              2     5
             / \
            3   4

        Для него:
        Preorder:   1 2 3 4 5
        Inorder:    3 2 4 1 5
        Postorder:  3 4 2 5 1
    */

    printf("DFS Preorder\n");
    preorder(tr);
    printf("\n");

    printf("DFS Inorder\n");
    inorder(tr);
    printf("\n");

    printf("DFS Postorder\n");
    postorder(tr);
    printf("\n");

    return 0;
}