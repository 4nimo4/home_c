/*
//------------------------------------------------------
//  Балансировка двоичных деревьев
//------------------------------------------------------ 
Время выполнения базовых операций в дереве поиска линейно зависит от его
высоты. Но из одного и того же набора ключей можно построить разные деревья
поиска. Например, если мы имеем ключи: 1,2,3,4,5,6,7, то можно построить два
таких дерева, причём оба будут корректными деревьями поиска.

    1                                   4
      2                              2      6
       3                           1   3   5   7
        4
          5
           6 
             7

Для того чтобы построить дерево минимально возможной высоты, необходимо
либо заранее знать, из каких ключей оно будет состоять, или выполнять
балансировку дерева после добавления.

Если набор ключей известен заранее, то можно их упорядочить и
каждый раз выбирать медиану. Например, для набора ключей:
1,2,3,4,5,6,7 в качестве корня выбираем 4, ключи меньше четырёх
попадут в левое поддерево, ключи с большим корнем — в правое.
Для каждого из поддеревьев снова выбираем медиану из данного
набора и строим соответствующие поддеревья.

Однако набор ключей не всегда известен заранее.
🌲 Если ключи поступают по очереди, то построение дерева будет зависеть от
порядка их поступления.
🌲 Если при добавлении очередного узла количество узлов в левом и правом
поддеревьях какого-либо узла дерева станет различаться более, чем на 1,
🌳 то дерево не будет являться идеально сбалансированным, и
🌳 его надо будет перестраивать, чтобы восстановить свойства идеально
сбалансированного дерева поиска.

Рассмотрим некоторые виды сбалансированных деревьев поиска:
🌴 АВЛ-дерево. Сбалансированность определяется разностью высот правого и
левого поддеревьев любого узла. Если эта разность по модулю не превышает
1, то дерево считается сбалансированным.
🌴 Красно-черное дерево. Каждый узел имеет дополнительное свойство — цвет,
красный или черный.
🌴 SPLAY-дерево. Иногда их называют самоперестраивающимся деревом. В
отличие от двух предыдущих видов, у такого дерева нет никаких ограничений
на расположение узлов, а сбалансированность в среднем достигается за счёт
того, что каждый раз перед выполнением операции над узлом этот узел
перемещается в корень дерева.

//------------------------------------------------------
//  АВЛ-дерево
//------------------------------------------------------ 
Сбалансированность определяется разностью высот правого и левого поддеревьев
любого узла.
🌳 Если эта разность по модулю не превышает 1, то дерево считается
сбалансированным.
🌳 АВЛ — аббревиатура, образованная первыми буквами создателей (советских
учёных) Адельсон-Вельского Георгия Максимовича и Ландиса Евгения
Михайловича.

//------------------------------------------------------
//  Красно-чёрное дерево
//------------------------------------------------------ 
Каждый узел имеет дополнительное свойство — цвет, красный или черный.
Корень и листья окрашены в черный цвет.

//------------------------------------------------------
//  SPLAY-дерево
//------------------------------------------------------ 
Иногда их называют самоперестраивающимся деревом. В отличие от двух
предыдущих видов, у такого дерева нет никаких ограничений на расположение
узлов, а сбалансированность в среднем достигается за счёт того, что каждый раз
перед выполнением операции над узлом этот узел перемещается в корень дерева.

//------------------------------------------------------
//  АВЛ-деревья
//------------------------------------------------------ 
АВЛ-деревом называется такое дерево поиска, в котором для
любого его узла высоты левого и правого поддеревьев
отличаются не более, чем на единицу. 🌲🌳🌲

Для наглядности и простоты алгоритма будем хранить высоту в отдельном поле
height.
Традиционно, узлы АВЛ-дерева хранят не высоту, а разницу высот правого и левого
поддеревьев (так называемый balance factor), которая может принимать только три
значения -1, 0 и 1. В целом это не сильно влияет на объём занимаемых данных. Даже
если хранить только баланс-фактор в однобайтовой переменной, то из-за
выравнивания полей структуры по четырёхбайтной границе экономии не будет.

//------------------------------------------------------
//  Корректировка разбалансировки поддерева
//------------------------------------------------------
В процессе добавления или удаления узлов в дереве возможно возникновение
ситуации, когда balance factor некоторых узлов оказывается равными 2 или 2, т.е.
возникает разбалансировка поддерева.
🎋 Для корректировки ситуации применяются повороты вокруг узлов дерева.
🎋 Простой поворот влево(вправо):

Функции поворотов и балансировки не содержат ни циклов, ни рекурсии, а значит
выполняются за постоянное время, не зависящее от размера дерева.

Может возникнуть ситуация дисбаланса, когда высота правого поддерева узла
Z на 2 больше высоты левого поддерева (обратный случай является
симметричным и реализуется аналогично). h(T1) - h(Y) = 2.

В этом случае необходимо применить большой поворот вокруг Z. В данном
случае он сводится к двум простым — сначала правый поворот вокруг Y,
затем левый вокруг Z.

Удаление элемента из дерева аналогично удалению из любого двоичного дерева
поиска. Разница заключается в необходимости выполнять балансировку после
различных удалений.

*/

#include <stdint.h>   // фиксированные целочисленные типы (int32_t и др.)
#include <stdlib.h>   // функции работы с памятью (malloc, calloc, free)
#include <stdio.h>    // ввод-вывод (printf и др.)

// -----------------------------------------------------
// АВЛ-дерево: структура узла
// -----------------------------------------------------
struct node {
    int key;               // ключ узла
    uint32_t height;       // высота поддерева с корнем в этом узле
    struct node *left;     // левый потомок
    struct node *right;    // правый потомок
};

// -----------------------------------------------------
// Высота поддерева (для struct node)
// -----------------------------------------------------
uint32_t height(struct node* p)
{
    return p ? p->height : 0;  // если p == NULL, высота = 0
}

// -----------------------------------------------------
// Вычисляем баланс-фактор узла: h(правого) - h(левого)
// -----------------------------------------------------
int bfactor(struct node* p) 
{
    return (int)height(p->right) - (int)height(p->left);
}

// -----------------------------------------------------
// Пересчитываем высоту узла p по высотам его детей
// -----------------------------------------------------
void fixheight(struct node* p)
{
    uint32_t hl = height(p->left);
    uint32_t hr = height(p->right);
    p->height = (hl > hr ? hl : hr) + 1;
}

// -----------------------------------------------------
// Левый поворот вокруг Y
// -----------------------------------------------------
struct node* rotateleft(struct node* Y) 
{
    struct node* X = Y->right;
    Y->right = X->left;
    X->left = Y;
    fixheight(Y);
    fixheight(X);
    return X;
}

// -----------------------------------------------------
// Правый поворот вокруг X
// -----------------------------------------------------
struct node* rotateright(struct node* X) 
{
    struct node* Y = X->left;
    X->left = Y->right;
    Y->right = X;
    fixheight(X);
    fixheight(Y);
    return Y;
}

// -----------------------------------------------------
// Балансировка узла p
// -----------------------------------------------------
struct node* balance(struct node* p)
{
    fixheight(p);              // сначала обновляем высоту
    if (bfactor(p) == 2)       // правое поддерево выше левого на 2
    {
        if (bfactor(p->right) < 0)
            p->right = rotateright(p->right); // правый-левый случай
        return rotateleft(p);                 // правый-правый случай
    }
    if (bfactor(p) == -2)      // левое поддерево выше правого на 2
    {
        if (bfactor(p->left) > 0)
            p->left = rotateleft(p->left);    // левый-правый случай
        return rotateright(p);                // левый-левый случай
    }
    return p;  // балансировка не нужна
}

// -----------------------------------------------------
// Вставка узла в АВЛ-дерево (как в обычное BST, но с балансировкой)
// -----------------------------------------------------
struct node* insert(struct node *p, int k) 
{
    if (p == NULL) 
    {
        p = (struct node*)calloc(1, sizeof(struct node)); // height=0, left/right=NULL
        p->key = k;
        p->height = 1;  // высота листа = 1 (можно и 0, но тогда поправить printBFS)
        return p;
    }
    if (k < p->key)
        p->left = insert(p->left, k);
    else
        p->right = insert(p->right, k);

    return balance(p); // с балансировкой это уже АВЛ-дерево
}

// -----------------------------------------------------
// Поиск узла с минимальным ключом в АВЛ-дереве
// (самый левый узел)
// -----------------------------------------------------
struct node* findmin(struct node* p) {
    return p->left ? findmin(p->left) : p;
}

// -----------------------------------------------------
// Удаление минимального узла из АВЛ-дерева
// -----------------------------------------------------
struct node* removemin(struct node* p) {
    if (p->left == NULL)       // дошли до минимума
        return p->right;       // его правое поддерево поднимается наверх
    p->left = removemin(p->left);
    return balance(p);
}

// -----------------------------------------------------
// Удаление ключа k из дерева p (АВЛ-вариант)
// -----------------------------------------------------
struct node *removenode(struct node *p, int k)
{
    if (!p) 
        return NULL;            // элемент не найден

    if (k < p->key)
        p->left = removenode(p->left, k);
    else if (k > p->key)
        p->right = removenode(p->right, k);
    else // k == p->key — нашли узел для удаления
    {
        struct node* q = p->left;
        struct node* r = p->right;
        free(p);                // освобождаем удаляемый узел

        // Если правого поддерева нет,
        // то возвращаем левое (может быть NULL или одноузловое дерево)
        if (!r) 
            return q;

        // Иначе находим минимум в правом поддереве (последователь),
        // удаляем его из r и делаем его новым корнем этого поддерева.
        struct node* min = findmin(r);
        min->right = removemin(r);
        min->left = q;
        return balance(min);
    }
    return balance(p);
}

// -----------------------------------------------------
// Печать АВЛ-дерева (симметричный обход, Inorder)
// -----------------------------------------------------
void inorder_avl(struct node *root)
{
    if (!root) return;
    inorder_avl(root->left);
    printf("%d ", root->key);
    inorder_avl(root->right);
}

// -----------------------------------------------------
// Вспомогательная: печать всех узлов на уровне level (для АВЛ)
// -----------------------------------------------------
void printCurrentLevel_avl(struct node* root, int level)
{
    if (!root) return;

    if (level == 1)
        printf("%d ", root->key);
    else if (level > 1) {
        printCurrentLevel_avl(root->left,  level - 1);
        printCurrentLevel_avl(root->right, level - 1);
    }
}

// -----------------------------------------------------
// Печать АВЛ-дерева по уровням (приближённый BFS)
// Используем поле height как оценку высоты дерева.
// -----------------------------------------------------
void printBFS_avl(struct node* root)
{
    if (!root) return;

    // Максимальный уровень примерно равен root->height
    int h = (int)root->height;
    for (int i = 1; i <= h; ++i)
        printCurrentLevel_avl(root, i);
}

// -----------------------------------------------------
// main — создание АВЛ-дерева, печать, удаление
// -----------------------------------------------------
int main(void)
{
    struct node* tr = NULL; // пустое дерево (корень = NULL)

    // Строим АВЛ-дерево вставками
    tr = insert(tr, 1);
    tr = insert(tr, 3);
    tr = insert(tr, 5);
    tr = insert(tr, 6);
    tr = insert(tr, 7);
    tr = insert(tr, 10);
    tr = insert(tr, 15);
    tr = insert(tr, 13);
    tr = insert(tr, 18);

    printf("\nBFS (AVL)\n");
    printBFS_avl(tr);       // печать по уровням
    printf("\n");

    printf("Inorder (AVL)\n");
    inorder_avl(tr);        // печать (Inorder) — ключи по возрастанию
    printf("\n");

    // Пример удаления (удалим 7)
    tr = removenode(tr, 7);

    printf("\nAfter remove 7, BFS (AVL)\n");
    printBFS_avl(tr);
    printf("\n");

    printf("After remove 7, Inorder (AVL)\n");
    inorder_avl(tr);
    printf("\n");

    // Здесь по-хорошему нужно ещё рекурсивно освободить всё дерево (free всех узлов),
    // но для краткости это опущено.

    return 0;
}