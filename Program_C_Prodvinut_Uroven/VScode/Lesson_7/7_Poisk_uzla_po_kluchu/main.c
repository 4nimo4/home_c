/*
//------------------------------------------------------
//  Поиск узла в двоичном дереве
//------------------------------------------------------ 
При поиске ключа в дереве, необходимо
сравнивать его со значением в текущим узле:
🌳 Если текущее поддерево пустое, то такого
ключа нет
🌳 Если в значение ключа в текущем
поддереве равно искомому, то ключ найден
🌳 Если значение искомого ключа меньше то
осуществлять переход в левое поддерево
🌳 Если значение искомого ключа больше то
осуществлять переход в правое поддерево

*/

#include <stdint.h>
#include <stdlib.h>
#include <stdio.h>

// Узел бинарного дерева поиска
typedef struct tree {
    int key;                 // Ключ (значение) узла
    struct tree *left;       // Указатель на левое поддерево
    struct tree *right;      // Указатель на правое поддерево
    struct tree *parent;     // Указатель на родителя (не обязателен, но может пригодиться)
} tree;

//------------------------------------------------------
// Вычисление высоты дерева
//------------------------------------------------------
int heightTree(tree* p)
{
    if (p == NULL)
        return 0;  // Высота пустого дерева = 0
    else 
    {
        // Рекурсивно вычисляем высоту левого и правого поддеревьев
        int lheight = heightTree(p->left);
        int rheight = heightTree(p->right);

        // Высота дерева = max(левое, правое) + 1 (за текущий узел)
        if (lheight > rheight)
            return (lheight + 1);
        else
            return (rheight + 1);
    }
}

//------------------------------------------------------
// Печать всех узлов на заданном уровне (для обхода в ширину)
// level = 1 означает «печатаем этот узел»
//------------------------------------------------------
void printCurrentLevel(tree* root, int level)
{
    if (root == NULL)
        return;         // Ничего печатать

    else if (level == 1)  // Мы «спустились» до нужного уровня
        printf("%d ", root->key);

    else if (level > 1) 
    {
        // Сначала уходим в левое поддерево, уменьшая level
        // потом — в правое. Если поменять местами, изменится
        // порядок вывода на уровне (сначала правые, потом левые).
        printCurrentLevel(root->left, level - 1);
        printCurrentLevel(root->right, level - 1);
    }
}

//------------------------------------------------------
// Обход дерева в ширину (BFS) через уровни
// Реализован не через очередь, а через:
//   1) вычисление высоты,
//   2) печать уровней один за другим.
//------------------------------------------------------
void printBFS(tree* root)
{
    int h = heightTree(root);        // высота дерева
    for (int i = 1; i <= h; i++)     // для каждого уровня
        printCurrentLevel(root, i);  // печатаем все узлы этого уровня
}

//------------------------------------------------------
// Симметричный обход (Inorder): Left, Root, Right
// Для бинарного дерева поиска даёт отсортированный вывод ключей.
//------------------------------------------------------
void inorder(tree *root)
{
    if (root == NULL)
        return;

    if (root->left)
        inorder(root->left);      // сначала левое поддерево

    printf("%d ", root->key);     // потом сам узел (корень поддерева)

    if (root->right)
        inorder(root->right);     // затем правое поддерево
} 

//------------------------------------------------------
// Вставка ключа в бинарное дерево поиска
//   root — адрес указателя на корень (или на текущий подузел),
//   key  — добавляемый ключ,
//   pt   — указатель на родителя (для заполнения поля parent).
//
// Если *root == NULL, создаём новый узел здесь.
// Иначе рекурсивно спускаемся влево или вправо.
//------------------------------------------------------
void insert(tree **root, int key, tree *pt)
{
    if (!(*root)) {
        // Дошли до пустого места — создаём новый узел
        *root = calloc(1, sizeof(tree));  // память обнулена (left/right = NULL)
        (*root)->key = key;
        (*root)->parent = pt;
        // left и right уже равны NULL благодаря calloc
    }
    else if (key < (*root)->key)
        // Ключ меньше — идём в левое поддерево
        insert(&((*root)->left), key, *root);
    else
        // Ключ больше или равен — идём в правое поддерево
        // (т.е. дубликаты тоже уходят вправо)
        insert(&((*root)->right), key, *root);
}

//------------------------------------------------------
// Рекурсивный поиск ключа в дереве поиска
// Возвращает указатель на узел с заданным ключом или NULL,
// если такого ключа нет.
//------------------------------------------------------
tree* search_tree(tree *root, int32_t key)
{
    // Базовый случай: дошли до NULL или нашли нужный ключ
    if (root == NULL || root->key == key)
        return root;

    // Если искомый ключ меньше — ищем в левом поддереве
    else if (root->key > key)
        return search_tree(root->left, key);

    // Иначе — в правом поддереве
    else
        return search_tree(root->right, key);
}

//------------------------------------------------------
// Итеративный поиск ключа в дереве поиска
// Аналог search_tree, но без рекурсии.
//------------------------------------------------------
tree* search_tree_i(tree *root, int key)
{  
    tree *find = root;

    // Пока не дошли до NULL и не нашли ключ
    while (find && find->key != key) 
    {
        if (key < find->key)
            find = find->left;   // идём влево
        else
            find = find->right;  // идём вправо
    }
    // либо нашли ключ, либо вернули NULL
    return find;
}

//------------------------------------------------------
// main — создание дерева, печать, поиск
//------------------------------------------------------
int main(void)
{
    tree *tr = NULL; // пустое дерево

    // Строим дерево поиска
    insert(&tr, 10, NULL);
    insert(&tr, 5,  NULL);
    insert(&tr, 15, NULL);
    insert(&tr, 3,  NULL);
    insert(&tr, 7,  NULL);
    insert(&tr, 13, NULL);
    insert(&tr, 18, NULL);
    insert(&tr, 1,  NULL);
    insert(&tr, 6,  NULL);

    printf("\nBFS\n");
    printBFS(tr);
    printf("\n");

    printf("Inorder\n");
    inorder(tr);
    printf("\n");

    // Добавим новый элемент (8)
    insert(&tr, 8, NULL);

    printf("BFS\n");
    printBFS(tr);
    printf("\n");

    printf("Inorder\n");
    inorder(tr);
    printf("\n");

    // Поиск ключа 7 (рекурсивная версия)
    tree *node = search_tree(tr, 7);
    if (node)
        printf("\nsearch_tree = %d\n", node->key);
    else
        printf("\nNO\n");

    // Поиск ключа 7 (итеративная версия)
    node = search_tree_i(tr, 7);
    if (node)
        printf("\nsearch_tree_i = %d\n", node->key);
    else
        printf("\nNO_i\n");

    // Если нашли узел (node от итеративного поиска),
    // печатаем поддерево с этим узлом как корнем (Inorder)
    if (node)
    {
        printf("\nSubtree inorder from found node:\n");
        inorder(node);
        printf("\n");
    }
    else
        printf("\nNO\n");

    return 0;
}