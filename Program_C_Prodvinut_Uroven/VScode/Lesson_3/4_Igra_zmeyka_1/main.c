/*
//------------------------------------------------------
//       Постановка задачи
//------------------------------------------------------
Следующие несколько семинаров будет посвящены проекту «Системы
управления».
🐍 Рассматривать его мы будем упрощенно на мини-игре «Змейка»,
функционал которой сопоставим с работой сельскохозяйственных дронов,
роботов пылесосов и т.п..
🐍 Присутствуют схожие функции управления, сбора, выполняются задачи
реального времени.
//------------------------------------------------------
// План работы на текущую лекцию
//------------------------------------------------------
🐍 Добавление базовых структур данных
🐍 Описание логики игры (инициализация)
🐍 Добавление клавиш управления движением
🐍 Алгоритмы определения границ (циклическое движение змейки)
...
*/

#include <stdio.h>
#include <stdlib.h>
#include <time.h>
#include <ncurses.h>   // Библиотека ncurses для работы с текстовым интерфейсом в терминале
#include <inttypes.h>
#include <string.h>
#include <unistd.h>

//------------------------------------------------------
// Константы и перечисления
//------------------------------------------------------
#define MIN_Y 2   // Минимальная координата Y (например, чтобы не затирать строку подсказки сверху)

// Перечисление направлений движения змейки и кода остановки игры
// STOP_GAME = клавиша F10 (макрос ncurses KEY_F(10))
enum {LEFT=1, UP, RIGHT, DOWN, STOP_GAME=KEY_F(10)};

// Константы, связанные с размерами хвоста и едой
enum {
    MAX_TAIL_SIZE       = 100,  // Максимальный размер хвоста
    START_TAIL_SIZE     = 3,    // Начальный размер хвоста
    MAX_FOOD            = 20,   // Максимальное количество еды (на будущее)
    FOOD_EXPIRE_SECONDS = 10    // Время "жизни" еды (на будущее)
};

//------------------------------------------------------
// Структуры для управления и состояния змейки
//------------------------------------------------------
/*
Коды управления змейкой хранятся в структуре control_buttons.
Здесь задаём, на какие клавиши (коды ncurses) реагировать:
вверх, вниз, влево, вправо.
*/
struct control_buttons {
    int down;
    int up;
    int left;
    int right;
} control_buttons;

// Набор кнопок по умолчанию — стрелки клавиатуры
struct control_buttons default_controls = {
    KEY_DOWN,
    KEY_UP,
    KEY_LEFT,
    KEY_RIGHT
};

/*
Структура snake_t — "голова" змейки и связь с хвостом:
- x, y        — текущие координаты головы
- direction   — направление движения (LEFT, RIGHT, UP, DOWN)
- tsize       — текущий размер хвоста
- *tail       — указатель на массив элементов хвоста
- controls    — структура с привязкой клавиш управления
*/
typedef struct snake_t {
    int x;
    int y;
    int direction;
    size_t tsize;
    struct tail_t *tail;
    struct control_buttons controls;
} snake_t;

// Структура tail_t — один сегмент хвоста (просто координаты x, y)
typedef struct tail_t {
    int x;
    int y;
} tail_t;

//------------------------------------------------------
// Инициализация хвоста и головы змейки
//------------------------------------------------------
/*
Функция initTail:
заполняет массив хвоста начальными значениями (0,0) для всех сегментов.
*/
void initTail(tail_t t[], size_t size)
{
    struct tail_t init_t = {0, 0};
    for (size_t i = 0; i < size; i++)
    {
        t[i] = init_t;
    }
}

/*
Функция initHead:
задаёт начальные координаты головы и начальное направление движения.
*/
void initHead(snake_t *head, int x, int y)
{
    head->x = x;
    head->y = y;
    head->direction = RIGHT;   // По умолчанию — движение вправо
}

/*
Функция initSnake:
полная инициализация змейки:
- выделяется память под массив хвоста
- хвост обнуляется
- задаются координаты и направление головы
- присваиваются настройки управления
*/
void initSnake(snake_t *head, size_t size, int x, int y)
{
    // Выделяем память под максимальный хвост
    tail_t* tail = (tail_t*) malloc(MAX_TAIL_SIZE * sizeof(tail_t));

    // Обнуляем все сегменты хвоста
    initTail(tail, MAX_TAIL_SIZE);

    // Инициализируем голову
    initHead(head, x, y);

    // Привязываем хвост к голове
    head->tail = tail;
    head->tsize = size + 1;         // +1 — с учётом головы (зависит от логики автора)
    head->controls = default_controls;
}

//------------------------------------------------------
// Движение головы змейки (go)
//------------------------------------------------------
/*
Функция go:
- стирает предыдущую позицию головы
- в зависимости от направления изменяет координаты x,y
- реализует "циклическое" движение по краям окна (выход за границу —
  появление с другой стороны)
*/
void go(struct snake_t *head)
{
    char ch = '@';      // Символ, которым рисуем голову
    int max_x = 0, max_y = 0;

    // Получаем размеры окна терминала (кол-во строк и столбцов)
    getmaxyx(stdscr, max_y, max_x);

    // Очищаем предыдущую позицию головы (пишем пробел)
    mvprintw(head->y, head->x, " ");

    switch (head->direction)
    {
        case LEFT:
            // Если уходим за левую границу — переносим голову на правую
            if (head->x <= 0)
                head->x = max_x;
            mvprintw(head->y, --(head->x), "%c", ch);
            break;

        case RIGHT:
            // Если уходим за правую границу — переносим влево
            if (head->x >= max_x)
                head->x = 0;
            mvprintw(head->y, ++(head->x), "%c", ch);
            break;

        case UP:
            // Если уходим за верхнюю границу — переносим вниз
            if (head->y <= 0)
                head->y = max_y;
            mvprintw(--(head->y), head->x, "%c", ch);
            break;

        case DOWN:
            // Если уходим за нижнюю границу — переносим вверх
            if (head->y >= max_y)
                head->y = 0;
            mvprintw(++(head->y), head->x, "%c", ch);
            break;

        default:
            break;
    }

    // Обновляем экран после всех изменений
    refresh();
}

//------------------------------------------------------
// Движение хвоста змейки (goTail)
//------------------------------------------------------
/*
Логика движения хвоста:
- каждый сегмент "перемещается" на позицию предыдущего
- первый элемент хвоста (tail[0]) становится на предыдущие координаты головы
Таким образом создаётся иллюзия, что хвост тянется за головой.
*/
void goTail(struct snake_t *head)
{
    char ch = '*';  // Символ, которым рисуем хвост

    // Стираем последний сегмент хвоста (он "освобождается" при движении)
    mvprintw(head->tail[head->tsize - 1].y,
             head->tail[head->tsize - 1].x, " ");

    // Сдвигаем хвост справа налево: каждый сегмент принимает координаты предыдущего
    for (size_t i = head->tsize - 1; i > 0; i--)
    {
        head->tail[i] = head->tail[i - 1];

        // Рисуем сегмент только если координаты не (0,0) (чтобы не рисовать "мусор")
        if (head->tail[i].y || head->tail[i].x)
            mvprintw(head->tail[i].y, head->tail[i].x, "%c", ch);
    }

    // Первый сегмент хвоста "прилипает" к голове — принимает её текущие координаты
    head->tail[0].x = head->x;
    head->tail[0].y = head->y;
}

//------------------------------------------------------
// Изменение направления движения (changeDirection)
//------------------------------------------------------
/*
Функция changeDirection:
по коду нажатой клавиши (key) обновляет направление snake->direction.
Используются коды из структуры controls у конкретной змейки.
*/
void changeDirection(snake_t* snake, const int32_t key)
{
    if (key == snake->controls.down)
        snake->direction = DOWN;
    else if (key == snake->controls.up)
        snake->direction = UP;
    else if (key == snake->controls.right)
        snake->direction = RIGHT;
    else if (key == snake->controls.left)
        snake->direction = LEFT;
}

//------------------------------------------------------
// Функция main — точка входа в программу / игру
//------------------------------------------------------
int main()
{
    /*
    В main:
    - выделяем память под змейку
    - инициализируем её
    - настраиваем режим работы ncurses
    - запускаем игровой цикл до нажатия клавиши F10 (STOP_GAME)
    */

    // Выделяем память под структуру snake_t
    snake_t* snake = (snake_t*) malloc(sizeof(snake_t));

    // Инициализируем змейку: начальный размер хвоста и стартовые координаты головы
    initSnake(snake, START_TAIL_SIZE, 10, 10);

    // Инициализируем ncurses
    initscr();
    keypad(stdscr, TRUE);   // Включаем поддержку функциональных клавиш и стрелок
    raw();                  // Отключаем line buffering (символ попадает сразу в программу)
    noecho();               // Не отображаем вводимые символы автоматически
    curs_set(FALSE);        // Скрываем курсор

    // Выводим подсказку в верхней строке
    mvprintw(0, 0, "Use arrows for control. Press 'F10' for EXIT");

    // Не ждём нажатия клавиши бесконечно — таймаут 0 (неблокирующий getch)
    timeout(0);

    int key_pressed = 0;

    // Основной игровой цикл: пока не нажали клавишу выхода (F10)
    while (key_pressed != STOP_GAME)
    {
        // Считываем нажатую клавишу (может вернуть ERR, если ничего не нажато)
        key_pressed = getch();

        // Двигаем голову
        go(snake);

        // Двигаем хвост вслед за головой
        goTail(snake);

        // Небольшая задержка между кадрами (скорость змейки)
        timeout(100);

        // Меняем направление движения в зависимости от нажатой клавиши
        changeDirection(snake, key_pressed);
    }

    // Освобождаем память, выделенную под хвост и саму змейку
    free(snake->tail);
    free(snake);

    // Завершаем режим ncurses и возвращаем терминал в обычное состояние
    endwin();

    return 0;   // Успешное завершение программы
}