//--------------------------------------------------------
//  Дано целое число без знака, переверните все его биты и верните
//  число с перевёрнутыми битами.
//  Пример для 8 бит:  0b00001011 (11) → 0b11010000
//--------------------------------------------------------

#include <stdio.h>
#include <inttypes.h>

// Функция reverseBits:
// Принимает 32‑битное беззнаковое число num.
// Возвращает число, у которого биты записаны в обратном порядке.
//
// Пример (для 8 младших битов):
//   num        = abcdefgh
//   reverse    = hgfedcba
uint32_t reverseBits(uint32_t num)
{
    // Количество бит в типе uint32_t
    // sizeof(num) обычно 4, 4 * 8 = 32 бита.
    uint32_t NO_OF_BITS = sizeof(num) * 8;

    // Здесь будем накапливать результат с перевёрнутыми битами.
    uint32_t reverse_num = 0;

    // Перебираем все позиции битов от 0 до NO_OF_BITS-1
    for (uint32_t i = 0; i < NO_OF_BITS; i++)
    {
        // Проверяем, установлен ли бит на позиции i в исходном числе:
        // (1u << i) — маска с единицей на позиции i.
        if (num & (1u << i))
        {
            // Если бит i равен 1, то в результирующем числе
            // нужно установить 1 на "зеркальной" позиции:
            //   (NO_OF_BITS - 1 - i)
            //
            // Например, для 32 бит:
            //  i = 0  → позиция 31
            //  i = 1  → позиция 30
            //  ...
            //  i = 31 → позиция 0
            reverse_num |= 1u << ((NO_OF_BITS - 1) - i);
        }
        // Если бит i равен 0 — ничего делать не нужно,
        // так как reverse_num инициализирован нулём.
    }

    return reverse_num;
}

int main(void)
{
    uint32_t n;

    // Считываем беззнаковое 32‑битное число
    printf("Enter unsigned integer: ");
    if (scanf("%" SCNu32, &n) != 1) {
        printf("Input error\n");
        return 1;
    }

    // Переворачиваем биты
    uint32_t r = reverseBits(n);

    // Выводим исходное и результат в десятичном и шестнадцатеричном виде
    printf("Original:  %10" PRIu32 " (0x%08" PRIx32 ")\n", n, n);
    printf("Reversed:  %10" PRIu32 " (0x%08" PRIx32 ")\n", r, r);

    return 0;
}