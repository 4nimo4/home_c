/*-------------------------------------------------------------------
 * A1.c
 * ------------------------------------------------------------------
 * Шифр Цезаря
 * ------------------------------------------------------------------
  На стандартном потоке ввода задается целое неотрицательное число N 
  и последовательность допустимых символов в кодировке ASCII, 
  оканчивающаяся точкой. Допустимые символы - латинские буквы 'a' ... 
  'z', 'A' ... 'Z' и пробел. Требуется закодировать латинские буквы 
  ('a' ... 'z', 'A' ... 'Z') шифром Цезаря, пробелы вывести без изменения. 
  Число N задает сдвиг в шифре. Шифр Цезаря заключается в следующем 
  преобразовании. Пусть буквы алфавита пронумерованы от 0 до K - 1, 
  где K - число символов в алфавите. Тогда символ с номером n кодируется 
  символом с номером p = (n + N) mod K (mod - операция взятия остатка). 
  На стандартном потоке вывода напечатать зашифрованное сообщение, 
  оканчивающееся точкой. Преобразование требуется выполнять независимо 
  для заглавных и строчных латинских букв. 
  Указание: использовать массивы запрещается.
 * -------------------------------------------------------------------
 * Формат входных данных
 * 
 * -------------------------------------------------------------------	
 * Формат результата
 * 
 * -------------------------------------------------------------------
 */
#include <stdio.h>

int main(void) {
    int N;

    // читаем N
    if (scanf("%d", &N) != 1 || N < 0) 
    {
        return 0; // некорректный ввод
    }

    // нормализуем сдвиг к 0..25
    N = N % 26;

    int c;

    // пропускаем один пробельный символ после числа (пробел или перевод строки)
    //c = getchar();
    if (c == '\n' || c == ' ' || c == '\t' || c == '\r') 
    {
        // ок, продолжаем
    } 
    else if (c != EOF) 
    {
        ;
    }

    while ((c = getchar()) != EOF) 
    {
        if (c == '.') 
        {
            putchar('.');
            break;
        } 
        else if (c == ' ') 
        {
            // пробел не шифруем
            putchar(' ');
        } 
        else if (c >= 'a' && c <= 'z') 
        {
            int n = c - 'a';          // номер буквы 0..25
            int p = (n + N) % 26;     // новый номер
            putchar('a' + p);
        }
        else if (c >= 'A' && c <= 'Z') 
        {
            int n = c - 'A';          // номер буквы 0..25
            int p = (n + N) % 26;
            putchar('A' + p);
        } 
        else 
        {
            putchar(c);
        }
    }
    printf("\n");
    return 0;
}
