/*-------------------------------------------------------------------
 * A4.c
 * ------------------------------------------------------------------
 * Поиск последовательности бит
 * ------------------------------------------------------------------
 * На вход программе подается беззнаковое 32-битное целое число N и 
 * натуральное число K (1 ≤ K ≤ 31). Требуется взять K подряд идущих 
 * битов числа N так, чтобы полученное число было максимальным. 
 * Программа должна вывести полученное число.
 * ------------------------------------------------------------------
 * Формат входных данных
 * ------------------------------------------------------------------	
 * Формат результата
 * ------------------------------------------------------------------
 */

#include <stdio.h>
#include <inttypes.h>

int main(void)
{
    uint32_t N;   // беззнаковое 32-битное число
    int K;   // количество подряд идущих битов (1..31)

    // Считываем N
    if (scanf("%" SCNu32, &N) != 1) 
    {
        return 1;   // ошибка ввода
    }

    // Считываем K
    if (scanf("%" SCNu32, &K) != 1) 
    {
        return 1;   // ошибка ввода
    }

    // По условию: 1 ≤ K ≤ 31
    if (K == 0 || K > 31) 
    {
        return 1;   // некорректное K
    }

    // Маска из K единичных битов:
    // K = 3 -> 0b000...0111
    // K = 5 -> 0b000...11111
    uint32_t mask = (1u << K) - 1u;

    uint32_t max_val = 0;          // максимальное найденное значение
    int max_shift = 32 - K;   // максимальный сдвиг, чтобы не выйти за 32 бита

    // Перебираем все возможные "окна" из K бит.
    // i — номер младшего бита окна (0 — самый младший бит числа N).
    for (int i = 0; i <= max_shift; i++) {
        // Сдвигаем число N вправо на i бит, чтобы интересующее нас окно K бит
        // оказалось в младших разрядах, затем обрезаем маской.
        uint32_t val = (N >> i) & mask;

        if (val > max_val) {
            max_val = val;
        }
    }

    // Выводим максимальное значение, полученное из K подряд идущих битов
    printf("%" PRIu32 "\n", max_val);

    return 0;
}
