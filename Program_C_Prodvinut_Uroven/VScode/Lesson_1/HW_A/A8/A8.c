/*-------------------------------------------------------------------
 * A8.c
 * ------------------------------------------------------------------
 * Весы
 * ------------------------------------------------------------------
 * В стартер боксе Geek Brains есть электронные чашечные весы 
 * (вместимость каждой чашки 1 тонна) и гири массами 1г, 3г, 9г, 27г, 
 * и т.д. по одной штуке каждой массы. Менеджер из рекламного отдела 
 * взял такие весы и не знает, можно ли взвесить что-нибудь тяжелое 
 * и если можно, сколько гирь придется положить на весы 
 * (на любую чашку). Надо помочь ему.  
 * ------------------------------------------------------------------
 * * Формат входных данных
 * единственное натуральное число – масса взвешиваемого товара в 
 * граммах (не больше 1000000000).
 * ------------------------------------------------------------------	
 * Формат результата
 * единственное целое число – общее количество гирь или число –1 
 * если данный товар взвесить невозможно.
 * ------------------------------------------------------------------
 * Нужно понять, можно ли массу M
представить как сумму степеней тройки, где каждую гирю можно положить 
либо на левую чашу, либо на правую, либо не использовать.

Это классическая задача про сбалансированную троичную систему.
Каждое число можно представить в виде:

-1·3^k, 0·3^k, +1·3^k

что соответствует:

гиря на стороне товара,
гиря не используется,
гиря на противоположной чашке.
Удобный способ решения — перевод
M в «сбалансированное троичное» представление через обычное 
деление на 3 с обработкой остатков.

Алгоритм:

Пусть
m = M, count = 0.
Пока
m > 0: 
вычисляем остаток r = m % 3.
если r == 0: 
эта степень тройки не нужна, m = m / 3.
если r == 1: 
нужна одна гиря (со знаком +1), count++, m = m / 3.
если r == 2: 
это то же, что -1 (берём гирю на противоположную чашу),
count++ , и делаем «перенос»:
m = m / 3 + 1.
Если в процессе m никогда не становится отрицательной и мы просто дошли до
m == 0 — взвесить можно, ответ count .
Для положительных масс до 1 000 000 000 всегда существует представление, 
так что -1 по сути не понадобится.
 */

#include <stdio.h>

int main(void)
{
    long long M;      // масса товара в граммах (до 1 000 000 000)
    int count = 0;    // количество использованных гирь

    // Считываем массу
    if (scanf("%lld", &M) != 1 || M <= 0) {
        // Некорректный ввод или не натуральное число
        printf("-1\n");
        return 0;
    }

    // Копируем M в рабочую переменную
    long long m = M;

    // Переводим массу в "сбалансированное троичное" представление
    while (m > 0) {
        int r = m % 3;  // остаток при делении на 3: 0, 1 или 2

        if (r == 0) {
            // Текущая степень тройки не используется
            m /= 3;
        } else if (r == 1) {
            // Нужна одна гиря 3^k (класть на сторону, противоположную товару)
            count++;
            m /= 3;
        } else { // r == 2
            // Это то же, что -1 * 3^k:
            // кладём гирю на сторону товара, делаем перенос
            count++;
            m = m / 3 + 1;
        }
    }

    // Для всех M <= 1e9 представление существует, выводим количество гирь
    printf("%d\n", count);

    return 0;
}