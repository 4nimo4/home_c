/*
//------------------------------------------------------
//    Алгоритмы
//------------------------------------------------------ 
Разберём, как принято оценивать сложность алгоритма
Как побитовые операции используются в алгоритмах шифрования
Изучим некоторые алгоритмы и оценим их производительность:
🐟 Бинарное возведение в степень и числа Фибоначчи
🐠 Биномиальные коэффициенты и треугольник Паскаля
🐟 Обратная польская форма и инфиксная нотация
🐠 Хеш-функция
🐟 Zфункция

//------------------------------------------------------
//    Оценка сложности алгоритмов
//------------------------------------------------------ 
Существует два ресурса, которые необходимо оценить при составлении
алгоритма:
● Сложность по памяти
● Сложность по процессорному времени
Оба параметра зависят от размера входных данных, при этом точное время
обычно никого не интересует: оно зависит от процессора, размера и типа данных,
языка программирования и других параметров.
💡
Важна лишь асимптотическая сложность, т. е. сложность при стремлении размера входных
данных к бесконечности.

Для формализации оценки сложности алгоритма используется О-нотация, причём для простоты
понимания и наглядности в неё обычно включают только существенно значимый параметр.
Например, есть алгоритм, который выполняется за 10n5 + 2n итераций.
Как видно из выражения, на скорость гораздо больше будет влиять 10n5, чем 2n.
Поэтому сложность такого алгоритма будет O(n 5), т. е. 2n и коэффициент при n5 будут отброшены.
Такой алгоритм не зависит от данных. Например, вернуть элемент массива, зная
его индекс.

O(1) сложность
int arr[n];
a[0] = 1;

O(n) сложность
В таком алгоритме необходимо перебрать все n элементов в самом худшем
случае. Например, алгоритм поиска максимума в массиве из n элементов:

int arr[n];
size_t imax=0;
for(size_t i=1; i<n; i++) 
{
    if( a[i]>a[imax] )
        imax=i;

O(log2 n) сложность
Такую сложность имеет, например, алгоритм бинарного поиска. На каждом шаге
количество входных данных уменьшается в два раза.

int arr[n] = {10,20,30,40,50}; // отсортированный массив
int findme = 20; // то что будем искать в массиве
size_t ifind=0, start=0, end=n-1, middle;
while(1) 
{
    middle = (start+end)/2;
    if( arr[middle] == findme ) 
    {
        ifind=middle;
        break;
    } else if( arr[middle]<findme )
        start = middle;
    else
        end = middle;
}

O(n log n) сложность
Подобную сложность имеют такие хорошие алгоритмы сортировки, как:
сортировка слиянием, быстрая сортировка. Простой пример:
for(int i = 0; i < n; i++) //этот цикл выполнится n раз - O(n)
{
    for(int j = n; j > 0; j/=2) //этот цикл выполнится O(log n) раз
    {
        ...
    }
}

O(n2) сложность
В таких алгоритмах обычно два вложенных цикла, каждый из которых выполняет n
раз. Пример такого алгоритма — более медленные сортировка пузырьком
или сортировка вставками.
Еще один простой пример — поиск совпадающих элементов в массиве.

int arr[n] = {10,20,30,40,50,60,70,80,99,99};
_Bool hasduplicate = false;
for(size_t i=0; i<n ; i++)
    for(size_t j=0; j<n ; j++)
        if(i!=j && arr[i]==arr[j]) 
        {
            hasduplicate = true;
        }

O(2n) сложность
Такую сложность имеет рекурсивная реализация для вычисления чисел
Фибоначчи. Производительность функции удваивается для каждого элемента. Для
каждого числа происходит два вызова себя, пока число не станет равно единице.

int fibonacci(int number) 
{
    if (number <= 1) 
    {
        return number;
    } 
    else 
    {
        return fibonacci(number - 1) + fibonacci(number - 2);
    }
}

*/
//O(log2 n) сложность
#include <stdio.h>

int main(void)
{
    // Отсортированный массив для примера поиска
    int arr[] = {10, 20, 30, 40, 50};

    // Количество элементов массива.
    // sizeof(arr) — общий размер в байтах, sizeof(arr[0]) — размер одного элемента.
    size_t n = sizeof(arr) / sizeof(arr[0]);

    int findme = 20; // значение, которое ищем в массиве

    // ifind — индекс найденного элемента. Инициализируем значением n,
    // это "маркер" «не найдено», т.к. допустимые индексы от 0 до n-1.
    size_t ifind = n;

    // Границы текущего рассматриваемого подмассива [start..end]
    size_t start = 0;
    size_t end = n - 1;

    // Пока диапазон не пуст (start <= end) — продолжаем бинарный поиск.
    while (start <= end)
    {
        // Вычисляем средний индекс безопасным способом:
        // start + (end - start) / 2 предотвращает возможное переполнение
        // при суммировании больших индексов (start + end).
        size_t middle = start + (end - start) / 2;

        // Печатаем текущее состояние для отладки/наглядности
        printf("- start=%zu, end=%zu, middle=%zu, arr[middle]=%d\n",
               start, end, middle, arr[middle]);

        // Сравниваем значение в середине с искомым
        if (arr[middle] == findme)
        {
            // Нашли — сохраняем индекс и выходим из цикла
            ifind = middle;
            break;
        }
        else if (arr[middle] < findme)
        {
            // Если средний элемент меньше искомого — ищем в правой половине.
            // Устанавливаем start = middle + 1, чтобы исключить уже проверенный middle.
            start = middle + 1;
        }
        else
        {
            // Если средний элемент больше искомого — ищем в левой половине.
            // Защита от вычитания из 0 для size_t (unsigned): если middle == 0, то
            // middle - 1 вызовет underflow. В таком случае цикл можно завершить.
            if (middle == 0)
                break;

            // Исключаем middle из следующего диапазона
            end = middle - 1;
        }
    }

    // Проверяем, был ли найден элемент (ifind != n)
    if (ifind != n)
        printf("Found at index: %zu\n", ifind);
    else
        printf("Not found\n");

    return 0;
}