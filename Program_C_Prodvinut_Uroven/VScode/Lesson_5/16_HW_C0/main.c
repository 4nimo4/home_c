/*
//------------------------------------------------------
//   C1-Префикс и суффикс
//------------------------------------------------------ 
На стандартном потоке ввода задаются две символьные строки, разделённые символом 
перевода строки. Каждая из строк не превышает по длине 10000 символов. 
В строках не встречаются пробельные символы. На стандартный поток вывода напечатайте два числа, 
разделённых пробелом: первое число — длина наибольшего префикса первой строки, 
являющегося суффиксом второй; второе число — наоборот, длина наибольшего суффикса первой строки, 
являющегося префиксом второй. 
Сравнение символов проводите с учётом регистра (т.е. символы 'a' и 'A' различны).
*/
#include <stdio.h>   
#include <string.h>  


int main(void)
{
    //Объявляем статический массив символов для хранения числа N как строки.
    //Размер 1000005: до 1 000 000 цифр + запас под '\0' и немного сверху.
    //static — чтобы массив размещался в статической памяти (а не на стеке). 
    static char s[1000005];

    //Считываем строку из стандартного ввода.
    //Формат "%1000000s" — читаем не более 1 000 000 символов, чтобы не выйти за пределы массива.
    //Если scanf вернул не 1 (не удалось прочитать строку), выходим из программы. 
    if (scanf("%1000000s", s) != 1)
        return 0;

    // Вычисляем длину строки s (количество символов — цифр в записи числа N). 
    int n = (int)strlen(s);
 
    //Если длина числа меньше 3, то из него нельзя получить ни одного трехзначного числа.
    //В этом случае сразу выводим 0 и завершаем программу. 
    if (n < 3) 
    {
        printf("Строка менее 3 символов n < 3, не подходит для вычисления!\n");
        return 0;       
    }
 
    //Переменная-счетчик: количество различных трехзначных чисел, которые можно получить вычеркиванием цифр. 
    int count = 0;

    //Внешний цикл по первой цифре трехзначного числа x.
    //x идет от 1 до 9, потому что первая цифра трехзначного числа не может быть 0 (без ведущих нулей). 
    for (int x = 1; x <= 9; x++) 
    {
           //Цикл по второй цифре трехзначного числа y. y может быть от 0 до 9. 
        for (int y = 0; y <= 9; y++) 
        {
            //Цикл по третьей цифре трехзначного числа z. z тоже может быть от 0 до 9. 
            for (int z = 0; z <= 9; z++) 
            {
                //Преобразуем цифры x, y, z в соответствующие символы. 
                char cx = '0' + x;  // символ первой цифры (от '1' до '9')
                char cy = '0' + y;  // символ второй цифры (от '0' до '9')
                char cz = '0' + z;  // символ третьей цифры (от '0' до '9')

                //Индекс i будем использовать для прохода по строке s.
                //Сначала ставим его в начало строки (позиция 0).
                int i = 0;

                //Ищем первую цифру cx в строке s. Пока не дошли до конца строки (i < n) и 
                //текущий символ s[i] не равен cx, двигаемся вправо (i++). */
                while (i < n && s[i] != cx)
                    i++;

                //Если дошли до конца строки (i == n), значит, символ cx нигде не встретился 
                //— трехзначное число с первой цифрой x построить нельзя. Переходим к следующей тройке (x,y,z).
                if (i == n) 
                    continue;

                //Если первую цифру нашли, сдвигаем индекс i на один вперед,
                //чтобы поиск второй цифры начинался ПОСЛЕ найденной первой.
                    i++;

                //Ищем вторую цифру cy после найденной первой.
                //Аналогично: пока не конец строки и текущий символ не равен cy — двигаемся дальше.
                while (i < n && s[i] != cy)
                    i++;

                //Если дошли до конца строки, значит вторую цифру cy найти не удалось,
                //трехзначное число с цифрами x,y,z построить нельзя — переходим к следующей тройке.
                if (i == n) 
                    continue;

                //Если вторую цифру нашли, снова сдвигаем индекс i, чтобы третью цифру искать ПОСЛЕ второй.
                    ++i;

                //Ищем третью цифру cz после найденной второй.
                while (i < n && s[i] != cz)
                    ++i;

                //Если и третью цифру не нашли (i == n), то трехзначное число xyz
                //НЕ может быть получено из данного N — переходим к следующей тройке.
                if (i == n) 
                    continue;

                /* Если эта строка выполнена, то:
                   - где‑то в строке s найдена первая цифра cx,
                   - правее — вторая цифра cy,
                   - ещё правее — третья цифра cz.
                   То есть существуют индексы i1 < i2 < i3, такие что:
                     s[i1] = cx, s[i2] = cy, s[i3] = cz.
                   Значит, трехзначное число xyz можно получить
                   вычеркиванием остальных цифр.
                   Увеличиваем счётчик таких различных чисел. */
                ++count;
            }
        }
    }

    //После перебора всех троек (x,y,z) в count содержится количество различных трехзначных чисел, 
    //которые можно получить из N, вычеркивая некоторые цифры.
    printf("%d\n", count);

    return 0;
}