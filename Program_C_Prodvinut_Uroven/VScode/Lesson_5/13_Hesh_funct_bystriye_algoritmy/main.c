/*
//------------------------------------------------------
//   Быстрые алгоритмы для создания хешей
//------------------------------------------------------ 
Алгоритм хеш-функции для строки, который использует
побитовые операции:
● Каждый бит введённой строки должен влиять на результат
полученного хеш.
● Один из простых способов сделать это — повернуть
текущий результат на некоторое количество бит, а затем
выполнить XOR текущего хэш-кода с текущим байтом.
● Поворот не должен быть кратен байту.
Не стоит использовать криптографические алгоритмы для
создания хешей. Даже если они работают быстро, для создания
хеш это всё же очень медленно.

Пример применения хеша:
Ещё один пример хеш-функции для строки использует побитовые операции.
Важно то, что функция должна работать максимально быстро.

Дано некоторое количество строк S[1..N], каждая длиной не более M символов.
Допустим, требуется найти все повторяющиеся строки и разделить их на такие
группы, чтобы в каждой из них были только одинаковые строки.
👷 Обычной сортировкой строк мы бы получили алгоритм со сложностью O (N
M log N), в то время как используя хэши, мы получим O (N M + N log N).
👷 Алгоритм. Посчитаем хэш от каждой строки, и отсортируем строки по этому
хэшу.


*/
#include <stdio.h>
#include <stdint.h>
#include <stdlib.h>
#include <inttypes.h>

/*
Программа:
- Читает TOTAL_STRINGS строк (каждая строка может содержать пробелы).
- Для каждой строки вычисляет хеш (функция getHash) и сохраняет строку и её хеш
  в структуру.
- Выводит список (строка: хеш).
- Сортирует массив структур по хешам с помощью qsort.
- Выводит отсортированный список.

В примере выше показаны строки теста (в комментарии) — несколько повторяющихся фраз.
*/

/* ---------------------- Три реализации хеш-функций ---------------------- */

/* Полиномиальный (псевдо-строчный) хеш.
   Идея: hash = Σ (val(ch) * p^i), где val(ch) = ch - 'a' + 1, p = 31.
   Примечания:
   - Предполагается, что вход — строчные латинские буквы 'a'..'z'. Для других символов
     формула может дать неожиданные (включая отрицательные) вклады, поэтому для
     общего случая стоит приводить (unsigned char) и/или нормализовать вход.
   - p_pow и hash растут быстро; в uint64_t они будут "переполняться" по модулю 2^64
     при длинных строках, что для хеш-функции допустимо (но увеличивает риск коллизий).
*/
uint64_t getHash(char const *s)
{
    const int p = 31;
    uint64_t hash = 0, p_pow = 1;
    while (*s) {
        hash += (uint64_t)(*s++ - 'a' + 1) * p_pow;
        p_pow *= p;
    }
    return hash;
}

/* DJB2 — простая и популярная строковая хеш-функция (Dan Bernstein).
   Формула: hash = hash * 33 + c.
   В коде используется начальная константа 5381.
   Здесь выражение в while написано аккуратно: присваивание и проверка значения.
*/
uint64_t getHash2(char const *str)
{
    uint64_t hash = 5381;
    int32_t c;
    while ((c = (unsigned char)*str++))  // явно приводим к unsigned char для безопасности
        hash = ((hash << 5) + hash) + (uint64_t)c; // hash * 33 + c
    return hash;
}

/* Вспомогательная функция циклического сдвига влево для 64-битного числа */
uint64_t rol(uint64_t n, size_t shift)
{
    return (n << shift) | (n >> (64 - shift));
}

/* Простейшая rotate-xor хеш-функция: XOR символа и поворот.
   Работает быстро, но криптографически и статистически слабее.
*/
uint64_t getHash3(char const *s)
{
    uint64_t result = 0x55555555ULL;
    while (*s) {
        result ^= (unsigned char)*s++;
        result = rol(result, 5);
    }
    return result;
}

/* ---------------------- Структуры и хранение ---------------------- */

enum { TOTAL_STRINGS = 10 };

/* Структура для хранения строки и её хеша.
   s[100] — допустимая длина строки (включая '\0'). */
struct strings {
    char s[100];
    uint64_t hash;
} strs[TOTAL_STRINGS];

/* ---------------------- Компаратор для qsort ---------------------- */

/* ВАЖНО:
   Возвращать разность uint64_t как int (как было у вас) — опасно и некорректно:
   - разность двух uint64_t может не поместиться в int;
   - при вычитании беззнаковых типов возможен underflow.
   Поэтому компаратор должен явно сравнивать и возвращать -1/0/1.
*/
int cmphashes(const void *a, const void *b)
{
    const struct strings *sa = (const struct strings *)a;
    const struct strings *sb = (const struct strings *)b;

    if (sa->hash < sb->hash) return -1;
    if (sa->hash > sb->hash) return 1;
    return 0;
}

/* ---------------------- main: чтение, хеширование, сортировка ---------------------- */

int main(void)
{
    /* Чтение строк:
       scanf(" %[^\n]", strs[i].s) — читает строку с пробелами до новой строки.
       Но это НЕ безопасно, если ввод длиннее буфера. Лучше ограничивать длину:
       scanf(" %99[^\n]", strs[i].s) или использовать fgets.
       Здесь оставлено как в вашем коде, но рекомендуется изменить.
    */
    for (size_t i = 0; i < TOTAL_STRINGS; i++) {
        if (scanf(" %99[^\n]", strs[i].s) != 1) {
            fprintf(stderr, "Input error or EOF at line %zu\n", i);
            return 1;
        }
        /* Записываем хеш (можно выбрать любую из трёх функций).
           В вашем варианте используется базовый полиномиальный getHash. */
        strs[i].hash = getHash(strs[i].s);
    }

    /* Печать до сортировки */
    puts("Before sort:");
    for (size_t i = 0; i < TOTAL_STRINGS; i++)
        printf("%s: %" PRIu64 "\n", strs[i].s, strs[i].hash);

    /* Сортируем по хешу */
    qsort(strs, TOTAL_STRINGS, sizeof(struct strings), cmphashes);

    /* Печать после сортировки */
    puts("---------------------Stored strings------------------------");
    for (size_t i = 0; i < TOTAL_STRINGS; i++)
        printf("%s: %" PRIu64 "\n", strs[i].s, strs[i].hash);

    return 0;
}
/*
Краткие замечания/рекомендации

Безопасный ввод: используйте fgets или ограниченную форму scanf ("%99[^\n]") 
— это убережёт от переполнения буфера.
Формат печати: для uint64_t используйте макросы из <inttypes.h>, например "%" PRIu64, 
для переносимости.
Компаратор qsort должен возвращать negative/zero/positive, а не разность беззнаковых типов.
Вычисления хеша: если хотите обрабатывать произвольные символы (включая пробелы/заглавные 
буквы), приведите символ к unsigned char и при необходимости нормализуйте (tolower).
Если требуется минимизировать коллизии, используйте двойной хеш (два независимых хеша) или 
большие модули/параметры.
Для больших объёмов строк или долгосрочного хранения подумайте про таблицу/бинарный 
поиск по хешам, проверку на коллизии и хранение исходных строк.
*/