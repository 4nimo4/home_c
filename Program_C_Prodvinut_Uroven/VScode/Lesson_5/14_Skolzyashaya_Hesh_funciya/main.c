/*
//------------------------------------------------------
//   Скользящая ХЕШ функция
//------------------------------------------------------ 
Используем в качестве примера шаблон текста «135» и текст «2135». Сначала
вычисляем хеш шаблона 135 по следующему алгоритму:
H(135) = 10^2*1 + 10^1*3 + 10^0*5 = 135
Затем вычисляем хеш первых m = 3 символов текста, т. е. 213:
H(213) = 10^2*2 + 10^1*1 + 10^0*3 = 213
Совпадения не произошло. Теперь сдвигаем подстроку, отбросив первый символ
предыдущего окна и добавив следующий. Получилось новая 135. Вычисляем для
неё хеш:
H(135) = 10^2*1 + 10^1*3 + 10^0*5 = 135
Хеши совпадают, подстрока найдена.

Обратите внимание: переместив скользящую подстроку, нам пришлось вычислить
весь хеш 213 и 135, что нежелательно, так как при этом мы вычислили хеш целых
чисел, которые уже были в предыдущем действии.
🏡 Скользящая хеш-функция может запросто устранить эти дополнительные
вычисления, убрав из подсчёта нового значения хеша первый символ
предыдущего и добавив новый символ.
🏡 Мы можем избавиться от хеш-значения этого убранного из подсчёта символа,
умножить полученное значение на основание, чтобы восстановить правильный
порядок степени предыдущих нетронутых символов и добавить значение
нового символа.

Так, мы можем вычислить хеш новой подстроки по формуле:
H = (H previous + C previous*pow strlen-1 )pow + C new
Hp - предыдущий хеш
C prevoius - предыдущий символ
C new - новый символ
strlen - размер строк
pow - константа
Используя предыдущий пример сдвига от 213 к 135, мы можем получить новый
хеш:
H =(213-2 *10^2)*10 +5=135
*/

#include <stdio.h> 
#include <stdint.h> 
#include <inttypes.h> // нужен для PRIu64 
#include <string.h>

// Шаблон и текст (для поиска вхождений шаблона в тексте) 
char s[100] = "135"; 
char text[100] = "21354562135";

// Основание системы счисления для хеширования (здесь цифры 0..9) 
uint64_t p = 10;

// Вычисляет числовой хеш подстроки длины len, используя основание p. 
//Осуществляется как: hash = hash * p + digit Предполагается, 
//что в строке только символы '0'..'9'.  
uint64_t getHash(char *str, size_t len) 
{ 
    uint64_t hash = 0; 
    char c; 
    for (size_t i = 0; i < len; i++) 
    { 
        c = str[i]; 
        hash *= p; // сдвиг разрядов в системе base=p 
        hash += (c - '0'); // добавление текущей цифры 
    } 
    return hash; 
}

int main(void) 
{ 
    // ht — массив хешей для всех окон длины lens в тексте 
    uint64_t ht[100] = {0}; uint64_t hs; // хеш шаблона s 
    uint64_t p_pow = 1; // p^(lens-1), используется при обновлении rolling-hash

    size_t lens = strlen(s);
    size_t lent = strlen(text);

    // Вычисляем хеш шаблона 
    hs = getHash(s, lens);

    // Вывод для отладки
    printf("%s\n", s);
    printf("%s\n", text);
    // Используем корректный спецификатор для uint64_t
    printf("s hash = %" PRIu64 "\n", hs);

    // p_pow = p^(lens-1) — множитель старшего разряда в окне длины lens.
   //Нужно, чтобы при переходе к следующему окну можно было убрать вклад
   //старшей цифры (см. ниже).
    for (size_t i = 1; i < lens; i++)
        p_pow *= p;

    // Хеш для первого окна текста (text[0..lens-1])
    ht[0] = getHash(&text[0], lens);
    printf("%" PRIu64 " ", ht[0]);

    // Проходим по всем последующим окнам текста длины lens.
    //Формула обновления (rolling hash), используемая здесь:
    // ht[i] = (ht[i-1] % p_pow) * p + value(new_digit)
    // Идея: ht[i-1] % p_pow убирает старшую цифру предыдущего окна,
   //затем умножение на p сдвигает разряды, и добавляем новую младшую цифру.
   //Важно: это корректно при условии, что ht[i-1] соответствует чистой
   //записи в системе base=p (т.е. нет неожиданных эффектов из-за переполнения).
    
    for (size_t i = 1; i < lent - lens + 1; i++)
    {
        ht[i] = (ht[i - 1] % p_pow) * p + (uint64_t)(text[lens + i - 1] - '0');

        // При совпадении хешей можно предположить вхождение шаблона.
       //Из‑за возможных коллизий при хешировании правильнее дополнительно
       //сравнить подстроку с шаблоном напрямую (strcmp). Здесь для краткости
       //только помечаем '!' при совпадении хешей.
        if (hs == ht[i])
            printf("!");
        printf("%" PRIu64 " ", ht[i]);
    }
    printf("\n");

    return 0;
}
