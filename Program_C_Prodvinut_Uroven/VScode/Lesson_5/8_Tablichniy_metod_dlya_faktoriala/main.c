/*
//------------------------------------------------------
//    Биномиальные коэффициенты - Табличный метод для факториала
//------------------------------------------------------ 
🧧 В некоторых ситуациях выгодно заранее посчитать значения всех факториалов.
🧧 Это нужно для того, чтобы впоследствии считать любой необходимый
биномиальный коэффициент, производя лишь два деления.

Ниже — полнофункциональная, безопасная и приемлемая реализация «табличного метода» 
для факториалов и вычисления биномиальных коэффициентов C(n,k). 
Учтены ограничения типов, проверка входных данных и аккуратная последовательная 
обработка делений, чтобы снизить риск переполнения.
Особенности реализации:
Факториалы предвычисляются в массиве factorial[0..NMAX].
Используется 128‑битная целочисленная арифметика (__int128) для промежуточных вычислений, 
чтобы расширить диапазон и безопасно перемножать/делить. 
(Компилятор GCC/Clang поддерживает __int128.)
При выводе результата используется unsigned long long (64-бит) — при желании 
можно вернуть __int128 и печатать его по-другому.
Все входы проверяются: 0 <= k <= n <= NMAX.
Для вычисления C(n,k) выполняются два деления подряд: сначала num /= factorial[k], 
затем num /= factorial[n-k]. Это корректно, потому что factorial[k] * factorial[n-k] 
делит factorial[n] ровно; использование 128‑битного типа избегает 
промежуточного переполнения.

*/
#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>

/*
 Табличный метод факториалов с применением __int128 для безопасности.
 Поддерживает n до NMAX (подбирается в зависимости от нужного диапазона).
*/

// Максимальное n, для которого предвычисляем факториалы.
// Для NMAX = 20 factorial[n] помещается в 64-битный unsigned long long.
// Использование __int128 в таблице позволяет безопаснее хранить большие факториалы,
// но даже __int128 переполнится для достаточно больших n (~34! уже > 2^127).
// Поэтому выбираем NMAX так, чтобы factorial[NMAX] помещался в __int128.
enum { NMAX = 30 }; // пример: 30! ~ 2.6525286e32, помещается в __int128 (~1.7e38)

typedef unsigned long long ull;
typedef __int128 i128;
typedef unsigned __int128 u128;

/* Предвычисление факториалов в виде unsigned __int128 */
void build_factorials(u128 fact[], int nmax)
{
    fact[0] = (u128)1;
    for (int i = 1; i <= nmax; ++i) {
        fact[i] = fact[i - 1] * (u128)i;
    }
}

/* Вспомогательная функция печати unsigned __int128 (в десятичном виде) */
void print_u128(u128 v)
{
    if (v == (u128)0) {
        putchar('0');
        return;
    }
    // соберём цифры в буфер в обратном порядке
    char buf[64];
    int pos = 0;
    while (v != (u128)0) {
        unsigned int digit = (unsigned int)(v % 10);
        buf[pos++] = '0' + digit;
        v /= 10;
    }
    // печатаем в правильном порядке
    for (int i = pos - 1; i >= 0; --i) putchar(buf[i]);
}

/*
 Вычисление C(n,k) с использованием таблицы факториалов.
 Возвращаемое значение — unsigned __int128 (точный целочисленный результат
 до предела, где factorial[n] помещается в u128).
*/
u128 cnk_table(int n, int k, u128 fact[], int nmax)
{
    // валидация
    if (n < 0 || k < 0 || k > n) {
        fprintf(stderr, "Invalid input: require 0 <= k <= n\n");
        return (u128)0;
    }
    if (n > nmax) {
        fprintf(stderr, "n too large for precomputed factorials (max %d)\n", nmax);
        return (u128)0;
    }

    // симметрия: C(n,k) == C(n,n-k)
    if (k > n - k) k = n - k;

    // Берём числитель как factorial[n] (в 128-бит)
    u128 num = fact[n];

    // Делим последовательно, чтобы избежать возможного переполнения при умножении знаменателя:
    // num /= factorial[k]; num /= factorial[n-k];
    // Это корректно (целочисленное деление без остатка), т.к. factorial[k]*factorial[n-k] | factorial[n].
    num /= fact[k];
    num /= fact[n - k];

    return num;
}

int main(void)
{
    // Таблица факториалов (unsigned __int128)
    static u128 fact[NMAX + 1];
    build_factorials(fact, NMAX);

    int n, k;
    if (scanf("%d%d", &n, &k) != 2) {
        fprintf(stderr, "Input error\n");
        return 1;
    }

    if (n < 0 || k < 0 || k > n || n > NMAX) {
        fprintf(stderr, "Invalid input or n > NMAX (%d). Provided n=%d k=%d\n", NMAX, n, k);
        return 1;
    }

    u128 res = cnk_table(n, k, fact, NMAX);

    // Печатаем результат — используем функцию для u128
    printf("C(%d,%d) = ", n, k);
    print_u128(res);
    printf("\n");

    return 0;
}
/*
Пояснения и рекомендации:
Почему __int128: использование 128‑битной промежуточной арифметики существенно расширяет 
допустимый диапазон n по сравнению с 64-битным long long. Тем не менее и __int128 
имеет предел: примерно до 34! включительно безопасно (34! ≈ 2.9523e38 < 2^127 ≈ 1.7e38 
— на грани; точный порог стоит проверять). Выбрано NMAX = 30 как разумный пример.
Если вам нужно значительно больше (n > 40–50), стоит применять библиотеку длинной 
арифметики (GMP, libtommath и т. п.), или хранить факториалы в разложении по простым 
множителям и затем уметь сокращать.
Последовательное деление (num /= fact[k]; num /= fact[n-k]) корректно математически и 
уменьшает риск переполнения по сравнению с вычислением знаменателя как произведения и 
последующим делением.
Табличный метод хорош, если вы выполняете много запросов C(n,k) после единственного 
предвычисления.
Внимание: при выборе NMAX учитывайте размер памяти и желаемую точность.
*/