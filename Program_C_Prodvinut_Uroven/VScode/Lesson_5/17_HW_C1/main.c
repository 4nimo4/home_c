/*
//------------------------------------------------------
//   C1-Префикс и суффикс
//------------------------------------------------------ 
На стандартном потоке ввода задаются две символьные строки, 
разделённые символом перевода строки. Каждая из строк не превышает 
по длине 10000 символов. В строках не встречаются пробельные символы. 
На стандартный поток вывода напечатайте два числа, разделённых пробелом: 
первое число — длина наибольшего префикса первой строки, являющегося 
суффиксом второй; второе число — наоборот, 
длина наибольшего суффикса первой строки, являющегося префиксом второй. 
Сравнение символов проводите с учётом регистра (т.е. символы 'a' и 'A' различны).

*/
#include <stdio.h>      // для функций ввода-вывода: scanf, printf
#include <string.h>     // для strlen

#define MAX_LEN 10005   // максимальная длина строки (чуть больше 10000 для запаса)

int main(void)
{
    char s1[MAX_LEN];  // первая строка
    char s2[MAX_LEN];  // вторая строка

    // 1) длина наибольшего префикса s1, являющегося суффиксом s2
    int pref1_suf2 = 0;
    // 2) длина наибольшего суффикса s1, являющегося префиксом s2
    int suf1_pref2 = 0;

    // читаем первую строку без пробелов (до пробела/перевода строки/конца файла)
    // "%10000s" — защита от переполнения буфера: максимум 10000 символов + '\0'
    if (scanf("%10000s", s1) != 1)
    {
        // если не прочитали первую строку, вывести 0 0 и завершить
        printf("%d %d\n", pref1_suf2, suf1_pref2);
        return 0;
    } 
        
    // читаем вторую строку тем же способом
    if (scanf("%10000s", s2) != 1) 
    {
        // если не прочитали вторую строку, тоже выводим 0 0 и выходим
        printf("%d %d\n", pref1_suf2, suf1_pref2);
        return 0;
    } 

    // длина первой строки
    int len1 = (int)strlen(s1);
    // длина второй строки
    int len2 = (int)strlen(s2);

    // максимально возможная длина общего префикса/суффикса —
    // не больше минимальной длины из двух строк
    int maxL = (len1 < len2) ? len1 : len2;

    /* --------- 1) Наибольший префикс s1, являющийся суффиксом s2 --------- */

    // Перебираем длины L от максимальной к меньшей (maxL, maxL-1, ..., 1)
    for (int L = maxL; L > 0; L--) 
    {
        int ok = 1;                     // флаг: пока считаем, что совпадение есть
        int start2 = len2 - L;          // индекс начала суффикса во второй строке

        // сравниваем L символов:
        //   префикс s1: s1[0..L-1]
        //   суффикс s2: s2[start2..start2+L-1]
        for (int i = 0; i < L; i++) 
        {
            if (s1[i] != s2[start2 + i]) 
            {
                ok = 0;     // нашли несовпадение, значит длина L не подходит
                break;      // выходим из внутреннего цикла по i
            }
        }

        if (ok) 
        {
            // если все L символов совпали, это максимальная подходящая длина
            pref1_suf2 = L;
            break;          // можно остановиться, дальше длины только меньше
        }
    }

    /* --------- 2) Наибольший суффикс s1, являющийся префиксом s2 --------- */

    // Снова перебираем длины L от максимальной к меньшей
    for (int L = maxL; L > 0; L--) 
    {
        int ok = 1;                     // флаг совпадения
        int start1 = len1 - L;          // индекс начала суффикса в первой строке

        // сравниваем L символов:
        //   суффикс s1: s1[start1..start1+L-1]
        //   префикс s2: s2[0..L-1]
        for (int i = 0; i < L; i++) 
        {
            if (s1[start1 + i] != s2[i]) 
            {
                ok = 0;     // нашлось несовпадение
                break;      // прекращаем проверку для этой длины L
            }
        }

        if (ok) 
        {
            // нашли наибольшую длину L, при которой
            // суффикс s1 совпадает с префиксом s2
            suf1_pref2 = L;
            break;          // дальше искать не нужно
        }
    }

    // печатаем два числа через пробел:
    // сначала длину префикса s1 = суффикса s2,
    // потом длину суффикса s1 = префикса s2
    printf("%d %d\n", pref1_suf2, suf1_pref2);
    return 0;
}