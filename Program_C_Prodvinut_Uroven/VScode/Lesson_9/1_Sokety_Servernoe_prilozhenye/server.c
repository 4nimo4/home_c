/*
//------------------------------------------------------ 
// Сокеты   - Серверное приложение
//------------------------------------------------------
// Что такое сокет? Какими они бывают?
//------------------------------------------------------
Сокет (от англ. Socket - разъем) – это название программного интерфейса для
обеспечения обмена данными между процессами. Бывают клиентские и
серверные сокеты.
Можно представить, что TCPсокет – это «труба» между двумя устройствами, в
которую с одного конца отправляются данные, а с другого принимаются.
К серверным сокетам могут подключиться несколько клиентских и работать
одновременно.
Серверные сокеты можно сравнить с коммутаторами, а клиентские с абонентами.

//------------------------------------------------------
// Установка сокет соединения
//------------------------------------------------------
Для взаимодействия между машинами необходимы адреса и номер порта. Адрес
представляет собой 4 числа, записанных через точки. Номер порта – целое число
от 0 до 65535.

  Адрес                     Адрес
192.168.0.2              192.168.0.1  
    порт                    порт
    6500       <-->         6500   
    
//------------------------------------------------------
// Приложение «Локальный чат» по протоколу TCP
//------------------------------------------------------
//              Постановка задачи
//------------------------------------------------------
Напишем приложение обмена сообщениями (чат) на виртуальной машине Linux
Нам потребуется два отдельных приложения – сервер и клиент
Чат работает по принципу «пинг-понг»: клиент и сервер обмениваются
сообщениями поочередно
Сообщение завершается символом “*ˮ
Для завершения соединения необходимо отправить символ #

//------------------------------------------------------
// Серверное приложение
//------------------------------------------------------
Для создания приложения «Локальный чат» на архитектуре «клиент-
сервер» на этапе соединения на сервере нам нужно выполнить
следующие шаги:
💻 Инициализация переменных                     - socket 
💻 Установка сокет соединения                   - socket 
💻 Инициализация структуры server_addrс         - bind
💻 Привязка сокета                              - bind
💻 Прослушивание сокета                         - listen
💻 Подключение клиентов                         - accept

socket -> bind -> listen -> accept

//------------------------------------------------------
// Инициализация переменных сервера (начало)
//------------------------------------------------------

struct sockaddr_in
{
    short  sin_family;
    u_short sin_port;
    struct in_addr sin_addr;
    char sin_zero[8];
};

6. serv_addr будет содержать адрес сервера
7. socklen_t - длиной по крайней мере 32 бита

*/

#include <stdio.h>      // printf, perror
#include <stdbool.h>    // тип bool
#include <string.h>     // memset, strlen
#include <sys/types.h>  // стандартные типы (ssize_t и др.)
#include <sys/socket.h> // socket, setsockopt, bind, listen, accept, recv, send
#include <netinet/in.h> // struct sockaddr_in, htons, htonl
#include <arpa/inet.h>  // inet_ntoa
#include <stdlib.h>     // exit, стандартные функции
#include <unistd.h>     // close

#define PORT 1500       // TCP-порт, на котором будет слушать сервер
#define BUF_SIZE 1024   // размер буфера для приёма/отправки данных

int main(void)
{
    int server_fd;          // дескриптор "слушающего" сокета (сервер)
    int client_fd = -1;     // дескриптор сокета подключённого клиента
    bool isExit = false;    // флаг завершения основного цикла
    char buffer[BUF_SIZE];  // буфер для приёма и отправки сообщений

    struct sockaddr_in server_addr; // структура с адресом сервера
    socklen_t addrlen = sizeof(server_addr);

    // 1. Создаём сокет
    // AF_INET      — IPv4
    // SOCK_STREAM  — потоковый сокет (TCP)
    // 0            — протокол по умолчанию (TCP для SOCK_STREAM)
    server_fd = socket(AF_INET, SOCK_STREAM, 0);
    printf("SERVER\n");
    if (server_fd < 0) {
        perror("socket");   // выводим системное сообщение об ошибке
        return 1;
    }
    printf("=> Socket server has been created...\n");

    // Разрешаем переиспользовать порт (SO_REUSEADDR), чтобы
    // при частом перезапуске сервера реже получать "Address already in use".
    int opt = 1;
    if (setsockopt(server_fd, SOL_SOCKET, SO_REUSEADDR, &opt, sizeof(opt)) < 0) {
        perror("setsockopt");
        close(server_fd);
        return 1;
    }

    // 2. Заполняем структуру адреса сервера
    memset(&server_addr, 0, sizeof(server_addr));   // обнуляем структуру
    server_addr.sin_family      = AF_INET;          // IPv4
    server_addr.sin_addr.s_addr = htonl(INADDR_ANY);// слушать на всех локальных интерфейсах
    server_addr.sin_port        = htons(PORT);      // порт в сетевом порядке байт

    // 3. Привязываем сокет к адресу/порту
    // После bind ядро будет направлять входящие соединения на этот порт в данный сокет.
    if (bind(server_fd, (struct sockaddr *)&server_addr, sizeof(server_addr)) < 0) {
        perror("bind");
        close(server_fd);
        return 1;
    }

    printf("=> Looking for clients on port %d...\n", PORT);

    // 4. Переводим сокет в режим прослушивания
    // listen делает сокет "пассивным" — он ждёт входящих подключений.
    if (listen(server_fd, 1) < 0) {
        perror("listen");
        close(server_fd);
        return 1;
    }

    // 5. Принимаем одно подключение
    // accept блокируется до прихода клиента, затем создаёт новый сокет client_fd
    // для общения с конкретным клиентом.
    client_fd = accept(server_fd, (struct sockaddr *)&server_addr, &addrlen);
    if (client_fd < 0) {
        perror("accept");
        close(server_fd);
        return 1;
    }

    printf("=> Connected with client %s\n", inet_ntoa(server_addr.sin_addr));
    printf("=> Type '#' to end the connection.\n\n");

    // 6. Основной цикл общения с клиентом
    while (!isExit) {
        ssize_t nbytes;

        // -------- ЧТЕНИЕ ОТ КЛИЕНТА --------
        printf("Client: ");
        fflush(stdout);  // выводим подсказку немедленно

        // recv читает данные из сокета client_fd
        nbytes = recv(client_fd, buffer, BUF_SIZE - 1, 0);
        if (nbytes <= 0) {
            // nbytes == 0 — клиент корректно закрыл соединение
            // nbytes < 0  — ошибка чтения (выводим perror)
            if (nbytes < 0) perror("recv");
            printf("\n=> Client disconnected.\n");
            break;
        }

        // Делаем из полученных байтов C-строку
        buffer[nbytes] = '\0';
        printf("%s\n", buffer);

        // Если клиент прислал строку, начинающуюся с '#', считаем это
        // командой завершения и выходим из цикла.
        if (buffer[0] == '#') {
            isExit = true;
            break;
        }

        // -------- ОТВЕТ СЕРВЕРА (ввод через getchar) --------
        printf("Server: ");
        fflush(stdout);

        // читаем посимвольно до символа новой строки '\n' или EOF
        int cntr = 0;
        int ch;

        // Если до этого в программе использовался scanf, иногда нужно
        // "съесть" лишний '\n' из буфера ввода:
        // ch = getchar();

        while ((ch = getchar()) != '\n' && ch != EOF && cntr < BUF_SIZE - 1) {
            buffer[cntr++] = (char)ch;
        }
        buffer[cntr] = '\0';  // завершаем строку нулём

        // Пустую строку можно не отправлять (по желанию)
        if (cntr == 0) {
            // ничего не набрали — переходим к следующей итерации
            continue;
        }

        // Отправляем введённую строку клиенту
        send(client_fd, buffer, strlen(buffer), 0);

        // Если первая буква ответа — '#', тоже считаем это командой выхода.
        if (buffer[0] == '#') {
            isExit = true;
            break;
        }
    }

    // Завершение работы: закрываем оба сокета
    printf("\n=> Connection terminated with IP %s\n", inet_ntoa(server_addr.sin_addr));
    close(client_fd);
    close(server_fd);
    printf("Goodbye...\n");

    return 0;
}